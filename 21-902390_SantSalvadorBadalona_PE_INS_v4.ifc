Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcDistributionPort (1448)
Name | FlowDirection | Group
Port_3025506_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025362_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025515_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025386_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025515_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025386_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025584_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025533_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025584_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025533_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025907_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025602_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025907_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025602_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025916_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025715_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025925_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025715_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025916_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025774_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025925_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025774_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025934_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025847_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025986_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025847_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025934_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025952_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026437_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025952_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025986_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026006_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026446_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026006_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026437_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026104_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026446_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026104_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026460_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026239_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026460_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026239_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026469_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026374_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026553_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026374_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026469_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026571_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027529_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026571_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027499_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026846_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027538_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026846_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027529_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027101_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027538_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027101_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027547_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027296_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027684_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027296_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027547_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027565_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028292_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027565_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027684_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027757_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028283_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027757_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028292_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027842_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028274_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027842_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028283_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027967_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028265_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027967_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028274_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028032_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028265_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028032_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028251_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028086_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028241_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028086_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028251_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028385_1 | SOURCEANDSINK | IF.FONT.Reg 2
Port_3028646_1 | SOURCEANDSINK | IF.FONT.Reg 3
Port_3028646_5 | SOURCEANDSINK | IF.FONT.Reg 3
Port_3028646_10 | SOURCEANDSINK | IF.FONT.Reg 3
Port_3028646_13 | SOURCEANDSINK | IF.FONT.Reg 3
Port_3029541_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3029541_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033555_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3029579_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033555_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3029579_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033552_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3029600_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033552_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3029600_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033549_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3029806_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033549_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3029806_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033546_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030244_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033543_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030244_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033546_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030372_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033540_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030372_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033543_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030565_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033540_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030565_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033537_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030685_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033537_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030685_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033534_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030820_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033530_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030820_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033534_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030990_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033530_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3030990_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033527_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031137_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033527_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031137_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033524_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031269_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033524_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031269_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033521_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031414_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033521_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031414_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033518_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031531_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033515_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031531_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033518_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031639_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033512_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031639_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033515_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031744_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033509_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031744_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033512_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031916_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033509_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031916_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033504_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031983_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033495_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3031983_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033504_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032023_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033495_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032023_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033492_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032063_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033483_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032063_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033492_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032201_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033443_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032201_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033434_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032308_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033425_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032308_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033434_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032420_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033425_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032420_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033416_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032472_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033416_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032472_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033407_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032519_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033398_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032519_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033407_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032561_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033398_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032561_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033389_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032628_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033389_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032628_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033380_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032705_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033380_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032705_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033371_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032792_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033362_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032792_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033371_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032882_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033362_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032882_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033353_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032977_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033353_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3032977_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033344_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033082_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033330_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033082_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033344_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033197_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033330_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033197_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033443_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033459_2 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033459_1 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3033483_0 | SOURCEANDSINK | IF.FONT.Reg 4
Port_3034136_1 | SOURCEANDSINK | IF.FONT.RegPrimari 1
Port_3034136_5 | SOURCEANDSINK | IF.FONT.RegPrimari 1
Port_3034136_10 | SOURCEANDSINK | IF.FONT.RegPrimari 1
Port_3036245_0 | SOURCEANDSINK | IF.FONT.RegPrimari 1
Port_3034136_13 | SOURCEANDSINK | IF.FONT.RegPrimari 1
Port_3034258_1 | SOURCEANDSINK | IF.FONT.Reg 7
Port_3034692_0 | SOURCEANDSINK | IF.FONT.Reg 7
Port_3034258_5 | SOURCEANDSINK | IF.FONT.Reg 7
Port_3034258_10 | SOURCEANDSINK | IF.FONT.Reg 7
Port_3034258_13 | SOURCEANDSINK | IF.FONT.Reg 7
Port_3034486_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3034528_1 | SOURCEANDSINK | IF.FONT.Reg 5
Port_3034629_0 | SOURCEANDSINK | IF.FONT.RegSecundari 1
Port_3034629_1 | SOURCEANDSINK | IF.FONT.RegSecundari 1
Port_3034692_1 | SOURCEANDSINK | IF.FONT.Reg 7
Port_3034873_1 | SOURCEANDSINK | IF.FONT.Reg 8
Port_3034873_5 | SOURCEANDSINK | IF.FONT.Reg 8
Port_3034873_10 | SOURCEANDSINK | IF.FONT.Reg 8
Port_3035048_0 | SOURCEANDSINK | IF.FONT.Reg 8
Port_3034873_13 | SOURCEANDSINK | IF.FONT.Reg 8
Port_3035048_1 | SOURCEANDSINK | IF.FONT.Reg 8
Port_3035248_0 | SOURCEANDSINK | IF.FONT.RegSecundari 2
Port_3035248_1 | SOURCEANDSINK | IF.FONT.RegSecundari 2
Port_3035696_1 | SOURCEANDSINK | IF.FONT.RegPrimari 1
Port_3035696_5 | SOURCEANDSINK | IF.FONT.RegPrimari 1
Port_3036245_1 | SOURCEANDSINK | IF.FONT.RegPrimari 1
Port_3035696_10 | SOURCEANDSINK | IF.FONT.RegPrimari 1
Port_3035696_13 | SOURCEANDSINK | IF.FONT.RegPrimari 1
Port_3038460_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3040877_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3040524_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3040947_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3040533_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3041131_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3040542_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3041371_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3040549_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3041858_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3040554_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044340_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3040559_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 1
Port_3044664_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 1
Port_3040877_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043261_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3040947_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043261_2 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3041131_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043490_2 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3041371_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043655_2 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3041858_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044223_2 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043261_4 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043560_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043490_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043560_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043490_4 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043734_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043655_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043734_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3043655_4 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044262_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044223_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044262_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044223_4 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044583_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044325_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044583_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044325_2 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044340_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044325_4 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044721_0 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3044664_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 1
Port_3044721_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3045926_2 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3045926_1 | SOURCEANDSINK | IF.FONT.RegPrimariBoquesReg 2
Port_3051132_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3051226_2 | SOURCEANDSINK | URB.DRE.General 3
Port_3051132_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3051316_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3052166_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3051316_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3351622_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3052213_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3372402_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3052213_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3077269_2 | SOURCEANDSINK | URB.DRE.General 3
Port_3077166_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3078954_4 | SOURCEANDSINK | URB.DRE.General 3
Port_3077166_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3354114_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3077269_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3077269_4 | SOURCEANDSINK | URB.DRE.General 3
Port_3077270_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3077270_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3078954_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3078955_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3078955_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3079089_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3079100_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3079089_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3080221_1 | SOURCEANDSINK
Port_3080221_2 | SOURCEANDSINK
Port_3080221_3 | SOURCEANDSINK
Port_3080221_4 | SOURCEANDSINK
Port_3080221_5 | SOURCEANDSINK
Port_3080221_6 | SOURCEANDSINK
Port_3080221_7 | SOURCEANDSINK
Port_3080221_8 | SOURCEANDSINK
Port_3080847_0 | SOURCEANDSINK | URB.DRE.Embornal 64
Port_3080847_1 | SOURCEANDSINK | URB.DRE.Embornal 64
Port_3081290_0 | SOURCEANDSINK | URB.DRE.Embornal 61
Port_3081290_1 | SOURCEANDSINK | URB.DRE.Embornal 61
Port_3081740_1 | SOURCEANDSINK
Port_3081740_2 | SOURCEANDSINK
Port_3081740_3 | SOURCEANDSINK
Port_3081740_4 | SOURCEANDSINK
Port_3081740_5 | SOURCEANDSINK
Port_3081740_6 | SOURCEANDSINK
Port_3081740_7 | SOURCEANDSINK
Port_3081740_8 | SOURCEANDSINK
Port_3082203_0 | SOURCEANDSINK | URB.DRE.Embornal 58
Port_3082203_1 | SOURCEANDSINK | URB.DRE.Embornal 58
Port_3082325_1 | SOURCEANDSINK
Port_3082325_2 | SOURCEANDSINK
Port_3082325_3 | SOURCEANDSINK
Port_3082325_4 | SOURCEANDSINK
Port_3082325_5 | SOURCEANDSINK
Port_3082325_6 | SOURCEANDSINK
Port_3082325_7 | SOURCEANDSINK
Port_3082325_8 | SOURCEANDSINK
Port_3084245_1 | SOURCEANDSINK
Port_3084245_2 | SOURCEANDSINK
Port_3084245_3 | SOURCEANDSINK
Port_3084245_4 | SOURCEANDSINK
Port_3084245_5 | SOURCEANDSINK
Port_3084245_6 | SOURCEANDSINK
Port_3084245_7 | SOURCEANDSINK
Port_3084245_8 | SOURCEANDSINK
Port_3084986_1 | SOURCEANDSINK
Port_3084986_2 | SOURCEANDSINK
Port_3084986_3 | SOURCEANDSINK
Port_3084986_4 | SOURCEANDSINK
Port_3084986_5 | SOURCEANDSINK
Port_3084986_6 | SOURCEANDSINK
Port_3084986_7 | SOURCEANDSINK
Port_3084986_8 | SOURCEANDSINK
Port_3085681_1 | SOURCEANDSINK
Port_3085681_2 | SOURCEANDSINK
Port_3085681_3 | SOURCEANDSINK
Port_3085681_4 | SOURCEANDSINK
Port_3085681_5 | SOURCEANDSINK
Port_3085681_6 | SOURCEANDSINK
Port_3085681_7 | SOURCEANDSINK
Port_3085681_8 | SOURCEANDSINK
Port_3086476_1 | SOURCEANDSINK
Port_3086476_2 | SOURCEANDSINK
Port_3086476_3 | SOURCEANDSINK
Port_3086476_4 | SOURCEANDSINK
Port_3086476_5 | SOURCEANDSINK
Port_3086476_6 | SOURCEANDSINK
Port_3086476_7 | SOURCEANDSINK
Port_3086476_8 | SOURCEANDSINK
Port_3089151_0 | SOURCEANDSINK | URB.DRE.Embornal 34
Port_3089151_1 | SOURCEANDSINK | URB.DRE.Embornal 34
Port_3089351_0 | SOURCEANDSINK | URB.DRE.Embornal 33
Port_3089351_1 | SOURCEANDSINK | URB.DRE.Embornal 33
Port_3089553_1 | SOURCEANDSINK
Port_3089553_2 | SOURCEANDSINK
Port_3089553_3 | SOURCEANDSINK
Port_3089553_4 | SOURCEANDSINK
Port_3089553_5 | SOURCEANDSINK
Port_3089553_6 | SOURCEANDSINK
Port_3089553_7 | SOURCEANDSINK
Port_3089553_8 | SOURCEANDSINK
Port_3089918_1 | SOURCEANDSINK
Port_3089918_2 | SOURCEANDSINK
Port_3089918_3 | SOURCEANDSINK
Port_3089918_4 | SOURCEANDSINK
Port_3089918_5 | SOURCEANDSINK
Port_3089918_6 | SOURCEANDSINK
Port_3089918_7 | SOURCEANDSINK
Port_3089918_8 | SOURCEANDSINK
Port_3090107_1 | SOURCEANDSINK
Port_3090107_2 | SOURCEANDSINK
Port_3090107_3 | SOURCEANDSINK
Port_3090107_4 | SOURCEANDSINK
Port_3090107_5 | SOURCEANDSINK
Port_3090107_6 | SOURCEANDSINK
Port_3090107_7 | SOURCEANDSINK
Port_3090107_8 | SOURCEANDSINK
Port_3090837_1 | SOURCEANDSINK
Port_3090837_2 | SOURCEANDSINK
Port_3090837_3 | SOURCEANDSINK
Port_3090837_4 | SOURCEANDSINK
Port_3090837_5 | SOURCEANDSINK
Port_3090837_6 | SOURCEANDSINK
Port_3090837_7 | SOURCEANDSINK
Port_3090837_8 | SOURCEANDSINK
Port_3091049_1 | SOURCEANDSINK
Port_3091049_2 | SOURCEANDSINK
Port_3091049_3 | SOURCEANDSINK
Port_3091049_4 | SOURCEANDSINK
Port_3091049_5 | SOURCEANDSINK
Port_3091049_6 | SOURCEANDSINK
Port_3091049_7 | SOURCEANDSINK
Port_3091049_8 | SOURCEANDSINK
Port_3116122_1 | SOURCEANDSINK
Port_3116122_2 | SOURCEANDSINK
Port_3116122_3 | SOURCEANDSINK
Port_3116122_4 | SOURCEANDSINK
Port_3116122_5 | SOURCEANDSINK
Port_3116122_6 | SOURCEANDSINK
Port_3116122_7 | SOURCEANDSINK
Port_3116122_8 | SOURCEANDSINK
Port_3126016_1 | SOURCEANDSINK
Port_3126016_2 | SOURCEANDSINK
Port_3126016_3 | SOURCEANDSINK
Port_3126016_4 | SOURCEANDSINK
Port_3126016_5 | SOURCEANDSINK
Port_3126016_6 | SOURCEANDSINK
Port_3126016_7 | SOURCEANDSINK
Port_3126016_8 | SOURCEANDSINK
Port_3126366_1 | SOURCEANDSINK
Port_3126366_2 | SOURCEANDSINK
Port_3126366_3 | SOURCEANDSINK
Port_3126366_4 | SOURCEANDSINK
Port_3126366_5 | SOURCEANDSINK
Port_3126366_6 | SOURCEANDSINK
Port_3126366_7 | SOURCEANDSINK
Port_3126366_8 | SOURCEANDSINK
Port_3133738_1 | SOURCEANDSINK
Port_3133738_5 | SOURCEANDSINK
Port_3133738_10 | SOURCEANDSINK
Port_3133738_13 | SOURCEANDSINK
Port_3134191_1 | SOURCEANDSINK
Port_3134191_5 | SOURCEANDSINK
Port_3134191_10 | SOURCEANDSINK
Port_3134191_13 | SOURCEANDSINK
Port_3134365_1 | SOURCEANDSINK
Port_3134365_5 | SOURCEANDSINK
Port_3134365_10 | SOURCEANDSINK
Port_3134365_13 | SOURCEANDSINK
Port_3134623_1 | SOURCEANDSINK
Port_3134623_5 | SOURCEANDSINK
Port_3134623_10 | SOURCEANDSINK
Port_3134623_13 | SOURCEANDSINK
Port_3242220_0 | SOURCEANDSINK | URB.DRE.Embornal 2
Port_3242220_1 | SOURCEANDSINK | URB.DRE.Embornal 2
Port_3242544_0 | SOURCEANDSINK | URB.DRE.Embornal 3
Port_3242544_1 | SOURCEANDSINK | URB.DRE.Embornal 3
Port_3325694_1 | SOURCEANDSINK
Port_3325694_2 | SOURCEANDSINK
Port_3325694_3 | SOURCEANDSINK
Port_3325694_4 | SOURCEANDSINK
Port_3325694_5 | SOURCEANDSINK
Port_3325694_6 | SOURCEANDSINK
Port_3325694_7 | SOURCEANDSINK
Port_3325694_8 | SOURCEANDSINK
Port_3347425_0 | SOURCEANDSINK | URB.DRE.Embornal 4
Port_3347425_1 | SOURCEANDSINK | URB.DRE.Embornal 4
Port_3348189_1 | SOURCEANDSINK
Port_3348189_2 | SOURCEANDSINK
Port_3348189_3 | SOURCEANDSINK
Port_3348189_4 | SOURCEANDSINK
Port_3348189_5 | SOURCEANDSINK
Port_3348189_6 | SOURCEANDSINK
Port_3348189_7 | SOURCEANDSINK
Port_3348189_8 | SOURCEANDSINK
Port_3349965_0 | SOURCEANDSINK | URB.DRE.Embornal 5
Port_3349965_1 | SOURCEANDSINK | URB.DRE.Embornal 5
Port_3349980_0 | SOURCEANDSINK | URB.DRE.Embornal 6
Port_3349980_1 | SOURCEANDSINK | URB.DRE.Embornal 6
Port_3350237_1 | SOURCEANDSINK
Port_3350237_2 | SOURCEANDSINK
Port_3350237_3 | SOURCEANDSINK
Port_3350237_4 | SOURCEANDSINK
Port_3350237_5 | SOURCEANDSINK
Port_3350237_6 | SOURCEANDSINK
Port_3350237_7 | SOURCEANDSINK
Port_3350237_8 | SOURCEANDSINK
Port_3351622_2 | SOURCEANDSINK | URB.DRE.General 3
Port_3351684_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3351683_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3372403_0 | SOURCEANDSINK | URB.DRE.General 3
InPort_3351683_2 | SINK | URB.DRE.General 3
OutPort_3371827_0 | SOURCE | URB.DRE.General 3
Port_3351683_4 | SOURCEANDSINK | URB.DRE.General 3
Port_3351684_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3352454_0 | SOURCEANDSINK | URB.DRE.Embornal 10
Port_3352454_1 | SOURCEANDSINK | URB.DRE.Embornal 10
Port_3353032_0 | SOURCEANDSINK | URB.DRE.Embornal 8
Port_3353032_1 | SOURCEANDSINK | URB.DRE.Embornal 8
Port_3353034_0 | SOURCEANDSINK | URB.DRE.Embornal 12
Port_3353034_1 | SOURCEANDSINK | URB.DRE.Embornal 12
Port_3353391_0 | SOURCEANDSINK | URB.DRE.Embornal 18
Port_3353391_1 | SOURCEANDSINK | URB.DRE.Embornal 18
Port_3353409_0 | SOURCEANDSINK | URB.DRE.Embornal 20
Port_3353409_1 | SOURCEANDSINK | URB.DRE.Embornal 20
Port_3353431_0 | SOURCEANDSINK | URB.DRE.Embornal 22
Port_3353431_1 | SOURCEANDSINK | URB.DRE.Embornal 22
Port_3353448_0 | SOURCEANDSINK | URB.DRE.Embornal 24
Port_3353448_1 | SOURCEANDSINK | URB.DRE.Embornal 24
Port_3353671_0 | SOURCEANDSINK | URB.DRE.Embornal 26
Port_3353671_1 | SOURCEANDSINK | URB.DRE.Embornal 26
Port_3353691_0 | SOURCEANDSINK | URB.DRE.Embornal 28
Port_3353691_1 | SOURCEANDSINK | URB.DRE.Embornal 28
Port_3353996_0 | SOURCEANDSINK | URB.DRE.Embornal 32
Port_3353996_1 | SOURCEANDSINK | URB.DRE.Embornal 32
Port_3354012_0 | SOURCEANDSINK | URB.DRE.Embornal 35
Port_3354012_1 | SOURCEANDSINK | URB.DRE.Embornal 35
Port_3354261_0 | SOURCEANDSINK | URB.DRE.Embornal 37
Port_3354261_1 | SOURCEANDSINK | URB.DRE.Embornal 37
Port_3354450_0 | SOURCEANDSINK | URB.DRE.Embornal 40
Port_3354450_1 | SOURCEANDSINK | URB.DRE.Embornal 40
Port_3355300_0 | SOURCEANDSINK | URB.DRE.Embornal 41
Port_3355466_2 | SOURCEANDSINK | URB.DRE.Embornal 41
Port_3355300_1 | SOURCEANDSINK | URB.DRE.Embornal 41
InPort_3355466_1 | SINK | URB.DRE.Embornal 41
OutPort_2637143_2 | SOURCE | URB.DRE.Embornal 41
Port_3355622_1 | SOURCEANDSINK
Port_3355622_2 | SOURCEANDSINK
Port_3355622_3 | SOURCEANDSINK
Port_3355622_4 | SOURCEANDSINK
Port_3355622_5 | SOURCEANDSINK
Port_3355622_6 | SOURCEANDSINK
Port_3355622_7 | SOURCEANDSINK
Port_3355622_8 | SOURCEANDSINK
Port_3356413_0 | SOURCEANDSINK | URB.DRE.Embornal 16
Port_3356413_1 | SOURCEANDSINK | URB.DRE.Embornal 16
Port_3356602_0 | SOURCEANDSINK | URB.DRE.Embornal 17
Port_3356602_1 | SOURCEANDSINK | URB.DRE.Embornal 17
Port_3356836_0 | SOURCEANDSINK | URB.DRE.Embornal 42
Port_3356836_1 | SOURCEANDSINK | URB.DRE.Embornal 42
Port_3357469_0 | SOURCEANDSINK | URB.DRE.Embornal 43
Port_3357469_1 | SOURCEANDSINK | URB.DRE.Embornal 43
Port_3359104_0 | SOURCEANDSINK | URB.DRE.Embornal 44
Port_3359104_1 | SOURCEANDSINK | URB.DRE.Embornal 44
Port_3359310_0 | SOURCEANDSINK | URB.DRE.Embornal 45
Port_3359310_1 | SOURCEANDSINK | URB.DRE.Embornal 45
Port_3360057_0 | SOURCEANDSINK | URB.DRE.Embornal 46
Port_3360057_1 | SOURCEANDSINK | URB.DRE.Embornal 46
Port_3360078_0 | SOURCEANDSINK | URB.DRE.Embornal 47
Port_3360078_1 | SOURCEANDSINK | URB.DRE.Embornal 47
Port_3360097_0 | SOURCEANDSINK | URB.DRE.Embornal 48
Port_3360097_1 | SOURCEANDSINK | URB.DRE.Embornal 48
Port_3360239_1 | SOURCEANDSINK
Port_3360239_2 | SOURCEANDSINK
Port_3360239_3 | SOURCEANDSINK
Port_3360239_4 | SOURCEANDSINK
Port_3360239_5 | SOURCEANDSINK
Port_3360239_6 | SOURCEANDSINK
Port_3360239_7 | SOURCEANDSINK
Port_3360239_8 | SOURCEANDSINK
Port_3360573_0 | SOURCEANDSINK | URB.DRE.Embornal 49
Port_3360573_1 | SOURCEANDSINK | URB.DRE.Embornal 49
Port_3360597_0 | SOURCEANDSINK | URB.DRE.Embornal 50
Port_3360597_1 | SOURCEANDSINK | URB.DRE.Embornal 50
Port_3360758_1 | SOURCEANDSINK
Port_3360758_2 | SOURCEANDSINK
Port_3360758_3 | SOURCEANDSINK
Port_3360758_4 | SOURCEANDSINK
Port_3360758_5 | SOURCEANDSINK
Port_3360758_6 | SOURCEANDSINK
Port_3360758_7 | SOURCEANDSINK
Port_3360758_8 | SOURCEANDSINK
Port_3361387_0 | SOURCEANDSINK | URB.DRE.Embornal 51
Port_3361387_1 | SOURCEANDSINK | URB.DRE.Embornal 51
Port_3361408_0 | SOURCEANDSINK | URB.DRE.Embornal 52
Port_3361408_1 | SOURCEANDSINK | URB.DRE.Embornal 52
Port_3361425_0 | SOURCEANDSINK | URB.DRE.Embornal 53
Port_3361425_1 | SOURCEANDSINK | URB.DRE.Embornal 53
Port_3361973_0 | SOURCEANDSINK | URB.DRE.Embornal 54
Port_3361973_1 | SOURCEANDSINK | URB.DRE.Embornal 54
Port_3361990_0 | SOURCEANDSINK | URB.DRE.Embornal 55
Port_3361990_1 | SOURCEANDSINK | URB.DRE.Embornal 55
Port_3366993_0 | SOURCEANDSINK | URB.DRE.Embornal 30
Port_3366993_1 | SOURCEANDSINK | URB.DRE.Embornal 30
Port_3371815_0 | SOURCEANDSINK | URB.DRE.NouCol·lector 2
Port_3371815_1 | SOURCEANDSINK | URB.DRE.NouCol·lector 2
Port_3371817_0 | SOURCEANDSINK | URB.DRE.NouCol·lector 4
Port_3371821_1 | SOURCEANDSINK | URB.DRE.NouCol·lector 4
Port_3371817_1 | SOURCEANDSINK | URB.DRE.NouCol·lector 4
Port_3371819_0 | SOURCEANDSINK | URB.DRE.NouCol·lector 4
Port_3371821_2 | SOURCEANDSINK | URB.DRE.NouCol·lector 4
Port_3371819_1 | SOURCEANDSINK | URB.DRE.NouCol·lector 4
Port_3371823_0 | SOURCEANDSINK | URB.DRE.NouCol·lector 3
Port_3371823_1 | SOURCEANDSINK | URB.DRE.NouCol·lector 3
Port_3371825_0 | SOURCEANDSINK | URB.DRE.NouCol·lector 5
Port_3371825_1 | SOURCEANDSINK | URB.DRE.NouCol·lector 5
InPort_3371827_0 | SINK | URB.DRE.NouCol·lector 1
OutPort_3351683_2 | SOURCE | URB.DRE.NouCol·lector 1
OutPort_3371827_1 | SOURCE | URB.DRE.NouCol·lector 1
Port_3372075_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3372414_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3372075_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3372110_2 | SOURCEANDSINK | URB.DRE.General 3
Port_3372092_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3372110_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3372092_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3372128_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3372116_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3372128_2 | SOURCEANDSINK | URB.DRE.General 3
Port_3372116_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3372140_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3372134_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3372140_2 | SOURCEANDSINK | URB.DRE.General 3
Port_3372134_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3372199_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3372414_2 | SOURCEANDSINK | URB.DRE.General 3
Port_3372199_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3372402_2 | SOURCEANDSINK | URB.DRE.General 3
Port_3372402_4 | SOURCEANDSINK | URB.DRE.General 3
Port_3372403_1 | SOURCEANDSINK | URB.DRE.General 3

# IfcElectricDistributionPoint: AMB.QuadreEletric:AMB.ELQ01.QuadreEletric, AMB.QuadreEletric:AMB.ELQ01.QuadreEletric:3220760
In: P0
Type - Classification: 70.40.10.30 Elements de la xarxa i control (Default Classification); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.10.30: Elements de la xarxa i control; 104.AMB.ClassificacioCodi: 70.40.10.30; 105.AMB.ClassificacioDescripcio: Elements de la xarxa i control; 109.AMB.CodiTipus: ELQ01; 111.AMB.DescripcioTipus: Quadre eléctric
Classification: 70.40.10.30 Elements de la xarxa i control (Default Classification); 70.40.10.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.QuadreEletric:AMB.ELQ01.QuadreEletric; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.ELQ01.QuadreEletric; 112.AMB.Servei: URB.EP; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Fase 2
5 AMB.Geometria - 507.AMB.Area: 4.6717 m2; 509.AMB.Volum: 1.11258 m3

# IfcFlowController: AMB.Reg.Anella:AMB.XRE01.AnellaReg.40mm (66)
In: P0
Type - Classification: 70.40.20.20 Accesoris de reg (Default Classification); Material: IF.FONT.RegSecundari
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.20: Accesoris de reg; 104.AMB.ClassificacioCodi: 70.40.20.20; 105.AMB.ClassificacioDescripcio: Accesoris de reg; 109.AMB.CodiTipus: XRE01; 111.AMB.DescripcioTipus: Anella de degoteig 40mm
Classification: 70.40.20.20 Accesoris de reg (Default Classification); 70.40.20.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.Reg.Anella:AMB.XRE01.AnellaReg.40mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRE01.AnellaReg.40mm; 112.AMB.Servei: IF.FONT.RegSecundari; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
2 AMB.Caracteristiques - 242.AMB.Mida: 40 mmø-40 mmø
5 AMB.Geometria - 507.AMB.Area: 0.0999909 m2; 509.AMB.Volum: 0.0015069 m3
Name (AMB.Reg.Anella:AMB.XRE01.AnellaReg.40mm:...) | 119.AMB.FaseCreacio | Group
2991923 | Fase 1 | IF.FONT.Reg 1
3022263 | Fase 1 | IF.FONT.Reg 1
3024810 | Fase 1 | IF.FONT.Reg 1
3024829 | Fase 1 | IF.FONT.Reg 1
3024848 | Fase 1 | IF.FONT.Reg 1
3025025 | Fase 1 | IF.FONT.Reg 1
3025044 | Fase 1 | IF.FONT.Reg 1
3025063 | Fase 1 | IF.FONT.Reg 1
3025082 | Fase 1 | IF.FONT.Reg 1
3025319 | Fase 1 | IF.FONT.Reg 1
3025362 | Fase 1 | IF.FONT.Reg 1
3025386 | Fase 1 | IF.FONT.Reg 1
3025533 | Fase 1 | IF.FONT.Reg 1
3025602 | Fase 1 | IF.FONT.Reg 1
3025715 | Fase 1 | IF.FONT.Reg 1
3025774 | Fase 1 | IF.FONT.Reg 1
3025847 | Fase 1 | IF.FONT.Reg 1
3025952 | Fase 1 | IF.FONT.Reg 1
3026006 | Fase 1 | IF.FONT.Reg 1
3026104 | Fase 1 | IF.FONT.Reg 1
3026239 | Fase 1 | IF.FONT.Reg 1
3026374 | Fase 1 | IF.FONT.Reg 1
3026571 | Fase 1 | IF.FONT.Reg 1
3026846 | Fase 1 | IF.FONT.Reg 1
3027101 | Fase 1 | IF.FONT.Reg 1
3027296 | Fase 1 | IF.FONT.Reg 1
3027565 | Fase 1 | IF.FONT.Reg 1
3027757 | Fase 1 | IF.FONT.Reg 1
3027842 | Fase 1 | IF.FONT.Reg 1
3027967 | Fase 1 | IF.FONT.Reg 1
3028032 | Fase 1 | IF.FONT.Reg 1
3028086 | Fase 1 | IF.FONT.Reg 1
3029541 | Fase 2 | IF.FONT.Reg 4
3029579 | Fase 2 | IF.FONT.Reg 4
3029600 | Fase 2 | IF.FONT.Reg 4
3029806 | Fase 2 | IF.FONT.Reg 4
3030244 | Fase 2 | IF.FONT.Reg 4
3030372 | Fase 2 | IF.FONT.Reg 4
3030565 | Fase 2 | IF.FONT.Reg 4
3030685 | Fase 2 | IF.FONT.Reg 4
3030820 | Fase 2 | IF.FONT.Reg 4
3030990 | Fase 2 | IF.FONT.Reg 4
3031137 | Fase 2 | IF.FONT.Reg 4
3031269 | Fase 2 | IF.FONT.Reg 4
3031414 | Fase 2 | IF.FONT.Reg 4
3031531 | Fase 2 | IF.FONT.Reg 4
3031639 | Fase 2 | IF.FONT.Reg 4
3031744 | Fase 2 | IF.FONT.Reg 4
3031916 | Fase 2 | IF.FONT.Reg 4
3031983 | Fase 2 | IF.FONT.Reg 4
3032023 | Fase 2 | IF.FONT.Reg 4
3032063 | Fase 2 | IF.FONT.Reg 4
3032201 | Fase 2 | IF.FONT.Reg 4
3032308 | Fase 2 | IF.FONT.Reg 4
3032420 | Fase 2 | IF.FONT.Reg 4
3032472 | Fase 2 | IF.FONT.Reg 4
3032519 | Fase 2 | IF.FONT.Reg 4
3032561 | Fase 2 | IF.FONT.Reg 4
3032628 | Fase 2 | IF.FONT.Reg 4
3032705 | Fase 2 | IF.FONT.Reg 4
3032792 | Fase 2 | IF.FONT.Reg 4
3032882 | Fase 2 | IF.FONT.Reg 4
3032977 | Fase 2 | IF.FONT.Reg 4
3033082 | Fase 2 | IF.FONT.Reg 4
3033197 | Fase 2 | IF.FONT.Reg 4
3033459 | Fase 2 | IF.FONT.Reg 4

# IfcFlowController: Boca de Reg:AMB.XRE08.BoquesReg (7)
In: P0
Type - Classification: 70.40.20.20 Accesoris de reg (Default Classification); Material: IF.FONT.RegPrimariBoquesReg
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.20: Accesoris de reg; 104.AMB.ClassificacioCodi: 70.40.20.20; 105.AMB.ClassificacioDescripcio: Accesoris de reg; 109.AMB.CodiTipus: XRE08; 111.AMB.DescripcioTipus: Boca de Reg
Classification: 70.40.20.20 Accesoris de reg (Default Classification); 70.40.20.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Boca de Reg:AMB.XRE08.BoquesReg; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRE08.BoquesReg; 112.AMB.Servei: IF.FONT.RegPrimariBoquesReg; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
2 AMB.Caracteristiques - 242.AMB.Mida: 63 mmø
5 AMB.Geometria - 507.AMB.Area: 0.956265 m2; 509.AMB.Volum: 0.0115103 m3
Name (Boca de Reg:AMB.XRE08.BoquesReg:...) | 119.AMB.FaseCreacio | Group
3038460 | Fase 2 | IF.FONT.RegPrimariBoquesReg 2
3040524 | Fase 2 | IF.FONT.RegPrimariBoquesReg 2
3040533 | Fase 2 | IF.FONT.RegPrimariBoquesReg 2
3040542 | Fase 2 | IF.FONT.RegPrimariBoquesReg 2
3040549 | Fase 1 | IF.FONT.RegPrimariBoquesReg 2
3040554 | Fase 1 | IF.FONT.RegPrimariBoquesReg 2
3040559 | Fase 1 | IF.FONT.RegPrimariBoquesReg 1

# IfcFlowFitting: AMB.Injert:AMB.CLU04.DerivacioEmbornalPVC, AMB.Injert:AMB.CLU04.DerivacioEmbornalPVC:3355466
In: P0
Type - Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); Material: AMB.PEAD
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLU04; 111.AMB.DescripcioTipus: Derivacio embornal PVC
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat); Group: URB.DRE.General 3; URB.DRE.Embornal 41
Pset_DistributionFlowElementCommon - Reference: AMB.Injert:AMB.CLU04.DerivacioEmbornalPVC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU04.DerivacioEmbornalPVC; 112.AMB.Servei: URB.DRE.Embornal; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Fase 1
2 AMB.Caracteristiques - 242.AMB.Mida: 400 mmø-400 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.0500619 m3

# IfcFlowFitting: AMB_Codo_PEAD_L2:AMB.XRT03.ColzeTubPolietile.Reg, AMB_Codo_PEAD_L2:AMB.XRT03.ColzeTubPolietile.Reg:3045926
In: P0
Type - Classification: 70.40.20.10 Canalitzacions de reg (Default Classification); Material: IF.FONT.RegPrimariBoquesReg
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.10: Canalitzacions de reg; 104.AMB.ClassificacioCodi: 70.40.20.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de reg; 109.AMB.CodiTipus: XRT03; 111.AMB.DescripcioTipus: Colze reduida tub de Polietile
Classification: 70.40.20.10 Canalitzacions de reg (Default Classification); 70.40.20.10 Uniformat (Uniformat); Group: IF.FONT.RegPrimariBoquesReg 2
Pset_DistributionFlowElementCommon - Reference: AMB_Codo_PEAD_L2:AMB.XRT03.ColzeTubPolietile.Reg; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRT03.ColzeTubPolietile.Reg; 112.AMB.Servei: IF.FONT.RegPrimariBoquesReg; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Fase 1
2 AMB.Caracteristiques - 242.AMB.Mida: 63 mmø-63 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000705218 m3

# IfcFlowFitting: AMB_Codo_PVC_L2:AMB.CLU01.ColzeDerivacioEmbornalPVC, AMB_Codo_PVC_L2:AMB.CLU01.ColzeDerivacioEmbornalPVC:2662483
In: P0
Type - Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); Material: URB.DRE.Embornal
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLU01; 111.AMB.DescripcioTipus: Colze derivació embornal de PVC
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat); Group: URB.DRE.Embornal 31
Pset_DistributionFlowElementCommon - Reference: AMB_Codo_PVC_L2:AMB.CLU01.ColzeDerivacioEmbornalPVC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU01.ColzeDerivacioEmbornalPVC; 112.AMB.Servei: URB.DRE.Embornal; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Fase 1
2 AMB.Caracteristiques - 242.AMB.Mida: 400 mmø-400 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.196223 m3

# IfcFlowFitting: AMB_Codo_PVC_L2:AMB.CLU03.ColzeCollectorNoVisitable (8)
In: P0
Type - Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); Material: URB.DRE.General
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLU03; 111.AMB.DescripcioTipus: Colze PVC col·lector no visitable
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat); Group: URB.DRE.General 3
Pset_DistributionFlowElementCommon - Reference: AMB_Codo_PVC_L2:AMB.CLU03.ColzeCollectorNoVisitable; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU03.ColzeCollectorNoVisitable; 112.AMB.Servei: URB.DRE.General; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Preexistència
Name (AMB_Codo_PVC_L2:AMB.CLU03.ColzeCollectorNoVisitable:...) | 242.AMB.Mida | 509.AMB.Volum (m3)
3051226 | 800 mmø-800 mmø | 1.62223
3052166 | 800 mmø-800 mmø | 1.67373
3079100 | 800 mmø-800 mmø | 1.48501
3351622 | 800 mmø-800 mmø | 1.67361
3372110 | 500 mmø-500 mmø | 0.408182
3372128 | 500 mmø-500 mmø | 0.408568
3372140 | 500 mmø-500 mmø | 0.408618
3372414 | 500 mmø-500 mmø | 0.408552

# IfcFlowFitting: AMB_Codo_PVC_L2:AMB.CLU06.ColzeCollectorSemiVisitable, AMB_Codo_PVC_L2:AMB.CLU06.ColzeCollectorSemiVisitable:3354114
In: P0
Type - Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); Material: URB.DRE.General
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLU06; 111.AMB.DescripcioTipus: Colze PVC col·lector semivisitable
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat); Group: URB.DRE.General 3
Pset_DistributionFlowElementCommon - Reference: AMB_Codo_PVC_L2:AMB.CLU06.ColzeCollectorSemiVisitable; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU06.ColzeCollectorSemiVisitable; 112.AMB.Servei: URB.DRE.General; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Preexistència
2 AMB.Caracteristiques - 242.AMB.Mida: 800 mmø-800 mmø
5 AMB.Geometria - 509.AMB.Volum: 1.6737 m3

# IfcFlowFitting: AMB_Codo_PVC_L2:AMB.CLU11.ColzeNouCollector, AMB_Codo_PVC_L2:AMB.CLU11.ColzeNouCollector:3371821
In: P0
Type - Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); Material: URB.DRE.NouCol·lector
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLU11; 111.AMB.DescripcioTipus: Colze PVC nou col·lector
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat); Group: URB.DRE.NouCol·lector 4
Pset_DistributionFlowElementCommon - Reference: AMB_Codo_PVC_L2:AMB.CLU11.ColzeNouCollector; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU11.ColzeNouCollector; 112.AMB.Servei: URB.DRE.NouCol·lector; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Fase 1
2 AMB.Caracteristiques - 242.AMB.Mida: 500 mmø-500 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.408627 m3

# IfcFlowFitting: AMB_Te-reducida_PEAD_L2:AMB.XRT02.TeTubPolietile.Reg (5)
In: P0
Type - Classification: 70.40.20.10 Canalitzacions de reg (Default Classification); Material: IF.FONT.RegPrimariBoquesReg
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.10: Canalitzacions de reg; 104.AMB.ClassificacioCodi: 70.40.20.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de reg; 109.AMB.CodiTipus: XRT02; 111.AMB.DescripcioTipus: Te reduida tub de Polietile
Classification: 70.40.20.10 Canalitzacions de reg (Default Classification); 70.40.20.10 Uniformat (Uniformat); Group: IF.FONT.RegPrimariBoquesReg 2
Pset_DistributionFlowElementCommon - Reference: AMB_Te-reducida_PEAD_L2:AMB.XRT02.TeTubPolietile.Reg; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRT02.TeTubPolietile.Reg; 112.AMB.Servei: IF.FONT.RegPrimariBoquesReg; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
2 AMB.Caracteristiques - 242.AMB.Mida: 63 mmø-63 mmø-63 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000958347 m3
Name (AMB_Te-reducida_PEAD_L2:AMB.XRT02.TeTubPolietile.Reg:...) | 119.AMB.FaseCreacio
3043261 | Fase 2
3043490 | Fase 2
3043655 | Fase 2
3044223 | Fase 1
3044325 | Fase 1

# IfcFlowFitting: AMB_Te-reducida_PVC_L2:AMB.CLU10.TeCollectorSemiVisitable (3)
In: P0
Type - Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); Material: URB.DRE.General
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLU10; 111.AMB.DescripcioTipus: Te reduida tub corrguat de polietilé
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat); Group: URB.DRE.General 3
Pset_DistributionFlowElementCommon - Reference: AMB_Te-reducida_PVC_L2:AMB.CLU10.TeCollectorSemiVisitable; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU10.TeCollectorSemiVisitable; 112.AMB.Servei: URB.DRE.General; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Preexistència
Name (AMB_Te-reducida_PVC_L2:AMB.CLU10.TeCollectorSemiVisitable:...) | 242.AMB.Mida | 509.AMB.Volum (m3)
3077269 | 800 mmø-800 mmø-800 mmø | 1.96067
3078954 | 800 mmø-800 mmø-800 mmø | 1.96236
3372402 | 800 mmø-800 mmø-500 mmø | 1.75233

# IfcFlowFitting: AMB_Te-reducida_PVC_L2:AMB.CLU12.TeNouCollector, AMB_Te-reducida_PVC_L2:AMB.CLU12.TeNouCollector:3351683
In: P0
Type - Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); Material: URB.DRE.General
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLU12; 111.AMB.DescripcioTipus: Te PVC nou col·lector
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat); Group: URB.DRE.NouCol·lector 1; URB.DRE.General 3
Pset_DistributionFlowElementCommon - Reference: AMB_Te-reducida_PVC_L2:AMB.CLU12.TeNouCollector; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU12.TeNouCollector; 112.AMB.Servei: URB.DRE.General; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Fase 1
2 AMB.Caracteristiques - 242.AMB.Mida: 800 mmø-800 mmø-500 mmø
5 AMB.Geometria - 509.AMB.Volum: 1.71516 m3

# IfcFlowSegment: Flex Pipe Round:AMB.EPT01.TubCorrugat (35)
In: P0
Type - PredefinedType: FLEXIBLESEGMENT; Material: URB.EP
Type - Pset_ElementShading - Roughness: 0.00004572 m
Type - Pset_ProductRequirements - Category: Flex Pipes
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.10.30: Elements de la xarxa i control; 104.AMB.ClassificacioCodi: 70.40.10.30; 105.AMB.ClassificacioDescripcio: Elements de la xarxa i control; 109.AMB.CodiTipus: EPT01; 111.AMB.DescripcioTipus: Tub corrguat de polietilé
Classification: 70.40.10.30 Elements de la xarxa i control (Default Classification); 70.40.10.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Flex Pipe Round:AMB.EPT01.TubCorrugat; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.EPT01.TubCorrugat; 112.AMB.Servei: URB.EP; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
2 AMB.Caracteristiques - 242.AMB.Mida: 160 mmø
5 AMB.Geometria - 505.AMB.Diametre: 0.16 m
Name (Flex Pipe Round:AMB.EPT01.TubCorrugat:...) | Length (m) = 501.AMB.Longitud (m) | 119.AMB.FaseCreacio | Group
2984811 | 14.4621 | Fase 2 | URB.EP 2
2984919 | 6.39458 | Fase 2 | URB.EP 3
2985016 | 8.96155 | Fase 2 | URB.EP 4
2985028 | 1.79562 | Fase 2 | URB.EP 4
2985044 | 14.5843 | Fase 2 | URB.EP 4
2985094 | 14.5684 | Fase 2 | URB.EP 4
2985114 | 14.528 | Fase 2 | URB.EP 4
2985126 | 14.5785 | Fase 2 | URB.EP 4
2985138 | 14.5749 | Fase 2 | URB.EP 4
2985150 | 14.5284 | Fase 2 | URB.EP 4
2985162 | 14.5008 | Fase 2 | URB.EP 4
2985182 | 14.5063 | Fase 2 | URB.EP 4
2985198 | 14.575 | Fase 2 | URB.EP 4
2985210 | 12.9366 | Fase 2 | URB.EP 4
2985222 | 1.24447 | Fase 2 | URB.EP 4
2985234 | 18.6319 | Fase 1 | URB.EP 4
2985246 | 1.18195 | Fase 1 | URB.EP 4
2985266 | 9.38786 | Fase 1 | URB.EP 4
2985322 | 13.2009 | Fase 1 | URB.EP 4
2985334 | 14.5571 | Fase 1 | URB.EP 4
2985346 | 14.5342 | Fase 1 | URB.EP 4
2985358 | 14.553 | Fase 1 | URB.EP 4
2985378 | 14.4732 | Fase 1 | URB.EP 4
2985390 | 14.5652 | Fase 1 | URB.EP 4
2985402 | 16.8201 | Fase 1 | URB.EP 4
2985414 | 14.9458 | Fase 1 | URB.EP 4
2985426 | 14.6011 | Fase 1 | URB.EP 4
2985438 | 4.53514 | Fase 1 | URB.EP 4
2985458 | 4.29142 | Fase 1 | URB.EP 4
2985474 | 7.71212 | Fase 1 | URB.EP 4
2985490 | 3.95912 | Fase 1 | URB.EP 4
2985502 | 14.5929 | Fase 1 | URB.EP 4
2985550 | 33.446 | Fase 2 | URB.EP 4
2985590 | 2.00008 | Fase 2 | URB.EP 5
2985637 | 32.6942 | Fase 2 | URB.EP 6

# IfcFlowSegment: Flex Pipe Round:AMB.XRT01.TubPolietile.Reg (89)
In: P0
Type - PredefinedType: FLEXIBLESEGMENT; Material: URB.EP
Type - Pset_ElementShading - Roughness: 0.00004572 m
Type - Pset_ProductRequirements - Category: Flex Pipes
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.10: Canalitzacions de reg; 104.AMB.ClassificacioCodi: 70.40.20.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de reg; 109.AMB.CodiTipus: XRT01; 111.AMB.DescripcioTipus: Tub de Polietile
Classification: 70.40.20.10 Canalitzacions de reg (Default Classification); 70.40.20.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Flex Pipe Round:AMB.XRT01.TubPolietile.Reg; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRT01.TubPolietile.Reg; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
Name (Flex Pipe Round:AMB.XRT01.TubPolietile.Reg:...) | Length (m) = 501.AMB.Longitud (m) | 112.AMB.Servei | 119.AMB.FaseCreacio | 242.AMB.Mida | 505.AMB.Diametre (m) | Group
2989801 | 0.511979 | URB.EP | Fase 2 | 160 mmø | 0.16 | URB.EP 4
2989814 | 0.541273 | URB.EP | Fase 2 | 160 mmø | 0.16 | URB.EP 4
2989827 | 0.321216 | URB.EP | Fase 2 | 160 mmø | 0.16 | URB.EP 3
2989840 | 0.287876 | URB.EP | Fase 2 | 160 mmø | 0.16 | URB.EP 7
2989973 | 0.263035 | URB.EP | Fase 2 | 160 mmø | 0.16 | URB.EP 5
3024949 | 2.7584 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025007 | 3.18376 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025272 | 8.14667 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025281 | 3.19679 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025290 | 2.59801 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025299 | 1.55271 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025497 | 6.62508 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025506 | 1.89388 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025515 | 1.73833 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025584 | 5.86589 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025907 | 14.6825 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025916 | 4.42363 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025925 | 1.35189 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025934 | 1.35763 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3025986 | 5.85044 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3026437 | 10.3974 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3026446 | 1.34119 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3026460 | 2.85686 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3026469 | 2.82406 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3026553 | 16.7364 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3027499 | 8.01134 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3027529 | 3.47096 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3027538 | 2.9755 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3027547 | 1.26829 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3027684 | 13.7785 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3028241 | 3.20112 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3028251 | 1.17387 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3028265 | 1.53965 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3028274 | 12.663 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3028283 | 4.42452 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3028292 | 7.34576 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3028385 | 2.87744 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 2
3033330 | 1.63863 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033344 | 1.11185 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033353 | 7.00209 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033362 | 1.40648 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033371 | 1.3768 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033380 | 7.40469 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033389 | 4.36466 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033398 | 11.9171 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033407 | 1.36585 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033416 | 2.92273 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033425 | 4.25724 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033434 | 2.9345 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033443 | 11.5695 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033483 | 4.2411 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033492 | 7.89886 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033495 | 1.49577 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033504 | 7.13728 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033509 | 7.39883 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033512 | 4.5318 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033515 | 1.44463 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033518 | 1.4848 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033521 | 7.40538 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033524 | 13.1927 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033527 | 7.88728 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033530 | 8.79117 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033534 | 1.82869 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033537 | 4.14052 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033540 | 3.94602 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033543 | 3.14328 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033546 | 3.83931 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033549 | 1.38728 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033552 | 2.85602 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3033555 | 3.099 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 4
3034486 | 33.8969 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 1
3034528 | 0.985291 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.Reg 5
3034629 | 3.00374 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.RegSecundari 1
3034692 | 2.24088 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 7
3035048 | 14.0178 | IF.FONT.RegSecundari | Fase 2 | 40 mmø | 0.04 | IF.FONT.Reg 8
3035248 | 11.0822 | IF.FONT.RegSecundari | Fase 1 | 40 mmø | 0.04 | IF.FONT.RegSecundari 2
3036245 | 16.9455 | IF.FONT.RegPrimari | Fase 2 | 63 mmø | 0.063 | IF.FONT.RegPrimari 1
3040877 | 36.3129 | IF.FONT.RegPrimariBoquesReg | Fase 2 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2
3040947 | 1.49728 | IF.FONT.RegPrimariBoquesReg | Fase 2 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2
3041131 | 1.74562 | IF.FONT.RegPrimariBoquesReg | Fase 2 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2
3041371 | 0.293832 | IF.FONT.RegPrimariBoquesReg | Fase 2 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2
3041858 | 1.56078 | IF.FONT.RegPrimariBoquesReg | Fase 1 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2
3043560 | 33.842 | IF.FONT.RegPrimariBoquesReg | Fase 2 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2
3043734 | 34.6418 | IF.FONT.RegPrimariBoquesReg | Fase 2 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2
3044262 | 37.4561 | IF.FONT.RegPrimariBoquesReg | Fase 1 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2
3044340 | 1.57522 | IF.FONT.RegPrimariBoquesReg | Fase 1 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2
3044583 | 36.1704 | IF.FONT.RegPrimariBoquesReg | Fase 1 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2
3044664 | 1.41052 | IF.FONT.RegPrimariBoquesReg | Fase 1 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 1
3044721 | 35.6742 | IF.FONT.RegPrimariBoquesReg | Fase 1 | 63 mmø | 0.063 | IF.FONT.RegPrimariBoquesReg 2

# IfcFlowSegment: Pipe Types:AMB.CLA02.DerivacioEmbornalPVC (56)
In: P0
Type - Material: URB.DRE.Embornal
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLA02; 111.AMB.DescripcioTipus: Nou embornal PVC
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.CLA02.DerivacioEmbornalPVC; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00000254 m
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLA02.DerivacioEmbornalPVC; 112.AMB.Servei: URB.DRE.Embornal; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
Name (Pipe Types:AMB.CLA02.DerivacioEmbornalPVC:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 119.AMB.FaseCreacio | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
2583072 | 3.06 | 9.3995 | Fase 1 | 400 mmø | 3.84531 | 0.4 | URB.DRE.Embornal 1
2607856 | 4.30881 | 9.16096 | Fase 1 | 400 mmø | 5.41461 | 0.4 | URB.DRE.Embornal 7
2608396 | 1.97371 | 6.93725 | Fase 1 | 400 mmø | 2.48023 | 0.4 | URB.DRE.Embornal 9
2608831 | 2.2 | 8.37934 | Fase 1 | 400 mmø | 2.7646 | 0.4 | URB.DRE.Embornal 11
2633400 | 2.2 | 6.76417 | Fase 1 | 400 mmø | 2.7646 | 0.4 | URB.DRE.Embornal 13
2633554 | 1.7 | 6.60764 | Fase 2 | 400 mmø | 2.13628 | 0.4 | URB.DRE.Embornal 15
2633774 | 2.3 | 6.73065 | Fase 2 | 400 mmø | 2.89027 | 0.4 | URB.DRE.Embornal 19
2633822 | 2.36 | 6.70597 | Fase 2 | 315 mmø | 2.33546 | 0.315 | URB.DRE.Embornal 21
2633908 | 2.3 | 7.01243 | Fase 2 | 315 mmø | 2.27608 | 0.315 | URB.DRE.Embornal 23
2633990 | 1.9 | 8.95212 | Fase 2 | 315 mmø | 1.88024 | 0.315 | URB.DRE.Embornal 25
2634259 | 2.1 | 7.42965 | Fase 2 | 315 mmø | 2.07816 | 0.315 | URB.DRE.Embornal 27
2634388 | 9.52 | 9.22387 | Fase 2 | 400 mmø | 11.9632 | 0.4 | URB.DRE.Embornal 29
2662464 | 0.00276708 | 7.80285 | Fase 1 | 315 mmø | 0.00273831 | 0.315 | URB.DRE.Embornal 31
2662479 | 0.00460016 | 7.94894 | Fase 1 | 315 mmø | 0.00455232 | 0.315 | URB.DRE.Embornal 31
2667557 | 10.105 | 8.35117 | Fase 1 | 400 mmø | 12.6983 | 0.4 | URB.DRE.Embornal 36
3080847 | 10.375 | 9.35317 | Fase 2 | 400 mmø | 13.0376 | 0.4 | URB.DRE.Embornal 64
3081290 | 10.295 | 9.31347 | Fase 2 | 400 mmø | 12.9371 | 0.4 | URB.DRE.Embornal 61
3082203 | 3.16 | 9.00937 | Fase 2 | 400 mmø | 3.97097 | 0.4 | URB.DRE.Embornal 58
3089151 | 8.655 | 8.37749 | Fase 1 | 400 mmø | 10.8762 | 0.4 | URB.DRE.Embornal 34
3089351 | 2.72417 | 8.40622 | Fase 1 | 400 mmø | 3.42329 | 0.4 | URB.DRE.Embornal 33
3242220 | 4.13479 | 8.1704 | Fase 1 | 400 mmø | 5.19593 | 0.4 | URB.DRE.Embornal 2
3242544 | 12.7 | 8.38483 | Fase 1 | 400 mmø | 15.9593 | 0.4 | URB.DRE.Embornal 3
3347425 | 9.555 | 8.38584 | Fase 1 | 400 mmø | 12.0072 | 0.4 | URB.DRE.Embornal 4
3349965 | 8.565 | 8.42642 | Fase 1 | 400 mmø | 10.7631 | 0.4 | URB.DRE.Embornal 5
3349980 | 3.02 | 8.27646 | Fase 1 | 400 mmø | 3.79504 | 0.4 | URB.DRE.Embornal 6
3352454 | 2.84014 | 7.89853 | Fase 1 | 400 mmø | 3.56903 | 0.4 | URB.DRE.Embornal 10
3353032 | 8.8 | 8.00426 | Fase 1 | 315 mmø | 8.70849 | 0.315 | URB.DRE.Embornal 8
