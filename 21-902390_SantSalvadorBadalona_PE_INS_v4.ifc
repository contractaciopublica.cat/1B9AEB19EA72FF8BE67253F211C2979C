Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 42d09826-b8b7-431c-b2f0-c4a6f263aad1, NumberOfSaves: 55], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: 0000/00
Time: 2023-04-03T17:07:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.6.2.0 - Alternate UI 22.6.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 03 17:07:53 2023 * Host: MSI * Database: C:\Users\CARLES~1\AppData\Local\Temp\0cd9c5e9-20f1-4b39-af7d-c7db49a6350b\300d18fc-f0da-4d69-9503-a3517f15c15a\ifc * Database version: 5507 * Database creation date: Mon Apr 03 17:07:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 03 17:07:15 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 03 17:07:15 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0000/00
LongName: Projecte de Reurbanització de l’Avinguda Sant Salvador i Carrer Guasch; Phase: PE
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 21-902390; 003.AMB.NomProjecte: Projecte de Reurbanització de l’Avinguda Sant Salvador i Carrer Guasch; 004.AMB.FaseProjecte: PE; 005.AMB.NomEdifici: Avinguda Sant Salvador i Carrer Guasch; 006.AMB.UsEdifici: Vial; 007.AMB.ModelDisciplina: INS; 008.AMB.Adreca: Àmbit de reurbanització de l’Avinguda Sant Salvador i Carrer Guasch; 009.AMB.Municipi: BADALONA; 010.AMB.AutorProjecte: Pedro García Figuera

# IfcSite, Àmbit de reurbanització de l’Avinguda Sant Salvador i Carrer Guasch
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 m
Pset_ProductRequirements - Category: Project Information
0 AMB.Informacio Projecte - 008.AMB.Adreca: Àmbit de reurbanització de l’Avinguda Sant Salvador i Carrer Guasch; 009.AMB.Municipi: BADALONA

# IfcBuilding, Avinguda Sant Salvador i Carrer Guasch
LongName: Avinguda Sant Salvador i Carrer Guasch
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
0 AMB.Informacio Projecte - 005.AMB.NomEdifici: Avinguda Sant Salvador i Carrer Guasch; 006.AMB.UsEdifici: Vial; 008.AMB.Adreca: Àmbit de reurbanització de l’Avinguda Sant Salvador i Carrer Guasch; 009.AMB.Municipi: BADALONA

# IfcBuildingStorey: Level:AMB_Nivell, P0
In: Avinguda Sant Salvador i Carrer Guasch
LongName: P0; Elevation: 0 m
Pset_AirSideSystemInformation - Name: P0
Pset_ProductRequirements - Name: P0; Category: Levels
1 AMB.Identificacio - 105.AMB.Nom: P0

# IfcBuildingElementProxy: AMB.ClavagueramExistent:AMB.CLA01.ClavagueramExistent, AMB.ClavagueramExistent:AMB.CLA01.ClavagueramExistent:3048346
In: P0
Type - Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLA01; 111.AMB.DescripcioTipus: Clavagueram Existent
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: AMB.ClavagueramExistent:AMB.CLA01.ClavagueramExistent; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLA01.ClavagueramExistent; 112.AMB.Servei: URB.DRE.General; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Preexistència
5 AMB.Geometria - 507.AMB.Area: 3556 m2; 509.AMB.Volum: 1056.43 m3

# IfcBuildingElementProxy: Base Replanteig:AMB.BaseReplanteix, Base Replanteig:AMB.BaseReplanteix:3118242
In: P0
Type - Classification: 00.10.10 Origen de coordenades (Default Classification); Material: FitaReplanteigText, FitaReplanteig
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 00.10.10: Origen de coordenades; 104.AMB.ClassificacioCodi: 00.10.10; 105.AMB.ClassificacioDescripcio: Origen de coordenades; 109.AMB.CodiTipus: n/a; 111.AMB.DescripcioTipus: Bases de replanteig
Classification: 00.10.10 Origen de coordenades (Default Classification); 00.10.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Base Replanteig:AMB.BaseReplanteix; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.BaseReplanteix; 112.AMB.Servei: n/a; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Fase 2
5 AMB.Geometria - 507.AMB.Area: 1.80905 m2; 509.AMB.Volum: 0.334409 m3

# IfcDistributionChamberElement: AMB.Arqueta.Reg:AMB.XRE03.PericoNetejaRegFormigo.40x40x45cm (4)
In: P0
Type - Classification: 70.40.20.30 Arquetes de reg (Default Classification); Material: AMB.Formigó
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.30: Arquetes de reg; 104.AMB.ClassificacioCodi: 70.40.20.30; 105.AMB.ClassificacioDescripcio: Arquetes de reg; 109.AMB.CodiTipus: XRE03; 111.AMB.DescripcioTipus: Perico neteja Reg 40x40x45cm
Classification: 70.40.20.30 Arquetes de reg (Default Classification); 70.40.20.30 Uniformat (Uniformat); Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: AMB.Arqueta.Reg:AMB.XRE03.PericoNetejaRegFormigo.40x40x45cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRE03.PericoNetejaRegFormigo.40x40x45cm; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
Name (AMB.Arqueta.Reg:AMB.XRE03.PericoNetejaRegFormigo.40x40x45cm:...) | 112.AMB.Servei | 119.AMB.FaseCreacio | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3021999 | IF.FONT.RegSecundari | Fase 1 | 1.2368 | 0.0679052 | IF.FONT.Reg 2
3024659 | IF.FONT.RegSecundari | Fase 1 | 1.2368 | 0.0679052 | IF.FONT.Reg 5
3034136 | IF.FONT.RegPrimari | Fase 2 | 1.18513 | 0.0678988 | IF.FONT.RegPrimari 1
3034258 | IF.FONT.RegSecundari | Fase 2 | 1.2368 | 0.0679052 | IF.FONT.Reg 7

# IfcDistributionChamberElement: AMB.Arqueta.Reg:AMB.XRE05.PericoValvulaBuidatRegFormigo.40x40x45cm (2)
In: P0
Type - Classification: 70.40.20.30 Arquetes de reg (Default Classification); Material: AMB.Formigó
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.30: Arquetes de reg; 104.AMB.ClassificacioCodi: 70.40.20.30; 105.AMB.ClassificacioDescripcio: Arquetes de reg; 109.AMB.CodiTipus: XRE05; 111.AMB.DescripcioTipus: Perico vàlvula buidat Reg 40x40x45cm
Classification: 70.40.20.30 Arquetes de reg (Default Classification); 70.40.20.30 Uniformat (Uniformat); Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: AMB.Arqueta.Reg:AMB.XRE05.PericoValvulaBuidatRegFormigo.40x40x45cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRE05.PericoValvulaBuidatRegFormigo.40x40x45cm; 112.AMB.Servei: IF.FONT.RegSecundari; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 1.2368 m2; 509.AMB.Volum: 0.0679052 m3
Name (AMB.Arqueta.Reg:AMB.XRE05.PericoValvulaBuidatRegFormigo.40x40x45cm:...) | 119.AMB.FaseCreacio | Group
3028646 | Fase 1 | IF.FONT.Reg 3
3034873 | Fase 2 | IF.FONT.Reg 8

# IfcDistributionChamberElement: AMB.Arqueta.Reg:AMB.XRE06.PericoRegFormigo.60x60x45cm, AMB.Arqueta.Reg:AMB.XRE06.PericoRegFormigo.60x60x45cm:3035696
In: P0
Type - Classification: 70.40.20.30 Arquetes de reg (Default Classification); Material: AMB.Formigó
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.30: Arquetes de reg; 104.AMB.ClassificacioCodi: 70.40.20.30; 105.AMB.ClassificacioDescripcio: Arquetes de reg; 109.AMB.CodiTipus: XRE06; 111.AMB.DescripcioTipus: Perico Reg 60x60x45cm
Classification: 70.40.20.30 Arquetes de reg (Default Classification); 70.40.20.30 Uniformat (Uniformat); Material: <Unnamed>; Group: IF.FONT.RegPrimari 1
Pset_DistributionFlowElementCommon - Reference: AMB.Arqueta.Reg:AMB.XRE06.PericoRegFormigo.60x60x45cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRE06.PericoRegFormigo.60x60x45cm; 112.AMB.Servei: IF.FONT.RegPrimari; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Fase 2
5 AMB.Geometria - 507.AMB.Area: 1.81345 m2; 509.AMB.Volum: 0.124892 m3

# IfcDistributionChamberElement: AMB.Embornal.5Connexions:AMB.CLU05.PouEmbornal.800x400x850mm (55)
In: P0
Type - Classification: 70.40.30.30 Arquetes i pous de drenatge (Default Classification); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.30: Arquetes i pous de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.30; 105.AMB.ClassificacioDescripcio: Arquetes i pous de drenatge; 109.AMB.CodiTipus: CLA05; 111.AMB.DescripcioTipus: Pou embornal
Classification: 70.40.30.30 Arquetes i pous de drenatge (Default Classification); 70.40.30.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.Embornal.5Connexions:AMB.CLU05.PouEmbornal.800x400x850mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU05.PouEmbornal.800x400x850mm; 112.AMB.Servei: URB.DRE.Embornal; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
Name (AMB.Embornal.5Connexions:AMB.CLU05.PouEmbornal.800x400x850mm:...) | 119.AMB.FaseCreacio | 507.AMB.Area (m2) | 509.AMB.Volum (m3)
2611430 | Fase 2 | 13.9689 | 0.911162
2662125 | Fase 1 | 10.9946 | 0.694442
2662160 | Fase 1 | 13.9689 | 0.911162
2664173 | Fase 1 | 10.9946 | 0.694442
2666359 | Fase 1 | 10.9946 | 0.694442
2666702 | Fase 1 | 11.5894 | 0.737786
2667374 | Fase 1 | 10.3997 | 0.651098
2667734 | Fase 1 | 10.3997 | 0.651098
2668089 | Fase 1 | 10.9946 | 0.694442
2668994 | Fase 1 | 11.5894 | 0.737786
3080736 | Fase 2 | 9.80486 | 0.607754
3081032 | Fase 2 | 10.9946 | 0.694442
3081884 | Fase 2 | 10.3997 | 0.651098
3082925 | Fase 2 | 10.9946 | 0.694442
3083302 | Fase 2 | 13.9689 | 0.911162
3083720 | Fase 2 | 13.9689 | 0.911162
3085136 | Fase 2 | 12.7791 | 0.824474
3091237 | Fase 2 | 13.9689 | 0.911162
3091962 | Fase 2 | 16.9431 | 1.12788
3092132 | Fase 2 | 13.9689 | 0.911162
3093220 | Fase 2 | 9.21 | 0.56441
3126836 | Fase 2 | 13.9689 | 0.911162
3126891 | Fase 2 | 13.9689 | 0.911162
3126972 | Fase 2 | 13.9689 | 0.911162
3127531 | Fase 1 | 13.9689 | 0.911162
3127600 | Fase 1 | 10.9946 | 0.694442
3127745 | Fase 1 | 16.9431 | 1.12788
3127836 | Fase 1 | 12.1843 | 0.78113
3128016 | Fase 1 | 10.9946 | 0.694442
3128195 | Fase 1 | 10.9946 | 0.694442
3128599 | Fase 1 | 10.9946 | 0.694442
3242186 | Fase 1 | 13.9689 | 0.911162
3242504 | Fase 1 | 10.9946 | 0.694442
3347395 | Fase 1 | 10.9946 | 0.694442
3349937 | Fase 1 | 11.5894 | 0.737786
3352156 | Fase 1 | 10.3997 | 0.651098
3352998 | Fase 1 | 11.5894 | 0.737786
3353300 | Fase 1 | 11.5894 | 0.737786
3353370 | Fase 1 | 11.5894 | 0.737786
3353636 | Fase 1 | 11.5894 | 0.737786
3353640 | Fase 1 | 11.5894 | 0.737786
3353914 | Fase 1 | 13.9689 | 0.911162
3354401 | Fase 1 | 12.1843 | 0.78113
3355279 | Fase 1 | 13.9689 | 0.911162
3356581 | Fase 2 | 13.9689 | 0.911162
3356808 | Fase 2 | 13.9689 | 0.911162
3357370 | Fase 2 | 16.9431 | 1.12788
3358881 | Fase 2 | 10.9946 | 0.694442
3359288 | Fase 2 | 10.3997 | 0.651098
3359960 | Fase 2 | 10.9946 | 0.694442
3360551 | Fase 2 | 13.9689 | 0.911162
3361359 | Fase 2 | 12.7791 | 0.824474
3361370 | Fase 2 | 12.7791 | 0.824474
3361938 | Fase 2 | 12.7791 | 0.824474
3361942 | Fase 2 | 12.7791 | 0.824474

# IfcDistributionChamberElement: AMB.Perico.Electrictat:AMB.EPP02.PericoFormigo.40x40x45cm (34)
In: P0
Type - Classification: 70.40.10.30 Elements de la xarxa i control (Default Classification); Material: AMB.Formigó
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.10.30: Elements de la xarxa i control; 104.AMB.ClassificacioCodi: 70.40.10.30; 105.AMB.ClassificacioDescripcio: Elements de la xarxa i control; 109.AMB.CodiTipus: EPP02; 111.AMB.DescripcioTipus: Perico enllumenat public 40x40x45cm
Classification: 70.40.10.30 Elements de la xarxa i control (Default Classification); 70.40.10.30 Uniformat (Uniformat); Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: AMB.Perico.Electrictat:AMB.EPP02.PericoFormigo.40x40x45cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.EPP02.PericoFormigo.40x40x45cm; 112.AMB.Servei: URB.EP; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 1.9054 m2; 509.AMB.Volum: 0.0874558 m3
Name (AMB.Perico.Electrictat:AMB.EPP02.PericoFormigo.40x40x45cm:...) | 119.AMB.FaseCreacio | Group
2965557 | Fase 1 | URB.EP 4
2966299 | Fase 1 | URB.EP 4
2966395 | Fase 1 | URB.EP 4
2966489 | Fase 1 | URB.EP 4
2966649 | Fase 1 | URB.EP 4
2966733 | Fase 1 | URB.EP 4
2966925 | Fase 1 | URB.EP 4
2967061 | Fase 1 | URB.EP 4
2967252 | Fase 1 | URB.EP 4
2967471 | Fase 1 | URB.EP 4
2967558 | Fase 1 | URB.EP 4
2967675 | Fase 1 | URB.EP 4
2967802 | Fase 1 | URB.EP 4
2967959 | Fase 1 | URB.EP 4
2968102 | Fase 1 | URB.EP 4
2968147 | Fase 1 | URB.EP 4
2968422 | Fase 2 | URB.EP 4
2968438 | Fase 2 | URB.EP 4
2968521 | Fase 2 | URB.EP 5
2968560 | Fase 2 | URB.EP 4
2968615 | Fase 2 | URB.EP 4
2968833 | Fase 2 | URB.EP 4
2969008 | Fase 2 | URB.EP 4
2969038 | Fase 2 | URB.EP 4
2969051 | Fase 2 | URB.EP 4
2969208 | Fase 2 | URB.EP 4
2969570 | Fase 2 | URB.EP 4
2969761 | Fase 2 | URB.EP 3
2971638 | Fase 1 | URB.EP 4
2972500 | Fase 2 | URB.EP 7
3133738 | Fase 2
3134191 | Fase 2
3134365 | Fase 2
3134623 | Fase 2

# IfcDistributionChamberElement: AMB.Pou:AMB.CLU08.PouSanejament.Ø1000mm (17)
In: P0
Type - Classification: 70.40.30.30 Arquetes i pous de drenatge (Default Classification); Material: <Unnamed>, AMB.FormigóPrefabricat
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.30: Arquetes i pous de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.30; 105.AMB.ClassificacioDescripcio: Arquetes i pous de drenatge; 109.AMB.CodiTipus: CLU08; 111.AMB.DescripcioTipus: Pou sanejament de Ø 1000mm
Classification: 70.40.30.30 Arquetes i pous de drenatge (Default Classification); 70.40.30.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.Pou:AMB.CLU08.PouSanejament.Ø1000mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU08.PouSanejament.Ø1000mm; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
2 AMB.Caracteristiques - 242.AMB.Mida: 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø
Name (AMB.Pou:AMB.CLU08.PouSanejament.Ø1000mm:...) | 112.AMB.Servei | 119.AMB.FaseCreacio | 501.AMB.Longitud (m) | 507.AMB.Area (m2) | 509.AMB.Volum (m3)
3080221 | URB.DRE.General | Preexistència | 3.57 | 28.2642 | 2.84886
3081740 | URB.DRE.General | Preexistència | 2.87 | 23.3852 | 2.32106
3082325 | URB.DRE.General | Preexistència | 2.87 | 23.3852 | 2.32106
3084245 | URB.DRE.General | Preexistència | 2.57 | 21.2942 | 2.09486
3084986 | URB.DRE.General | Preexistència | 2.27 | 19.2033 | 1.86866
3085681 | URB.DRE.General | Preexistència | 2.07 | 17.8093 | 1.71786
3086476 | URB.DRE.NouCol·lector | Fase 1 | 1.549 | 14.178 | 1.32503
3089553 | URB.DRE.NouCol·lector | Fase 1 | 1.69 | 15.1607 | 1.43135
3089918 | URB.DRE.General | Preexistència | 3.07 | 24.7792 | 2.47186
3090107 | URB.DRE.General | Preexistència | 2.07 | 17.8093 | 1.71786
3116122 | URB.DRE.General | Preexistència | 3.47 | 27.5672 | 2.77346
3325694 | URB.DRE.NouCol·lector | Fase 1 | 1.648 | 14.868 | 1.39968
3348189 | URB.DRE.NouCol·lector | Fase 1 | 1.555 | 14.2198 | 1.32956
3350237 | URB.DRE.NouCol·lector | Fase 1 | 1.541 | 14.1222 | 1.319
3355622 | URB.DRE.General | Preexistència | 1.87 | 16.4153 | 1.56707
3360239 | URB.DRE.General | Preexistència | 2.87 | 23.3852 | 2.32106
3360758 | URB.DRE.General | Preexistència | 2.57 | 21.2942 | 2.09486

# IfcDistributionChamberElement: AMB.PouSenseBase:AMB.CLU09.PouSanejament.Ø700mm (6)
In: P0
Type - Classification: 70.40.30.30 Arquetes i pous de drenatge (Default Classification); Material: <Unnamed>, AMB.FormigóPrefabricat
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.30: Arquetes i pous de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.30; 105.AMB.ClassificacioDescripcio: Arquetes i pous de drenatge; 109.AMB.CodiTipus: CLU09; 111.AMB.DescripcioTipus: Pou sanejament de Ø 700mm
Classification: 70.40.30.30 Arquetes i pous de drenatge (Default Classification); 70.40.30.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.PouSenseBase:AMB.CLU09.PouSanejament.Ø700mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU09.PouSanejament.Ø700mm; 112.AMB.Servei: URB.DRE.General; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
2 AMB.Caracteristiques - 242.AMB.Mida: 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø
Name (AMB.PouSenseBase:AMB.CLU09.PouSanejament.Ø700mm:...) | 119.AMB.FaseCreacio | 501.AMB.Longitud (m) | 507.AMB.Area (m2) | 509.AMB.Volum (m3)
2606344 | Fase 1 | 3.25 | 22.1916 | 1.7248
2608561 | Fase 1 | 3.05 | 20.8261 | 1.6117
3090837 | Fase 1 | 3.55 | 24.2398 | 1.89445
3091049 | Fase 1 | 3.25 | 22.1916 | 1.7248
3126016 | Fase 2 | 3.45 | 23.5571 | 1.8379
3126366 | Fase 2 | 3.25 | 22.1916 | 1.7248

# IfcDistributionChamberElement: AMB.TapaAdaptativaArquetaElectricitat:AMB.EPP01.TapaPerico.40x40cm (37)
In: P0
Type - Classification: 70.40.10.30 Elements de la xarxa i control (Default Classification); Material: AMB.Metall.Acer.Lacat.Negre
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.10.30: Elements de la xarxa i control; 104.AMB.ClassificacioCodi: 70.40.10.30; 105.AMB.ClassificacioDescripcio: Elements de la xarxa i control; 109.AMB.CodiTipus: EPP01; 111.AMB.DescripcioTipus: Tapa pericó enllumenat 40x40
Classification: 70.40.10.30 Elements de la xarxa i control (Default Classification); 70.40.10.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.TapaAdaptativaArquetaElectricitat:AMB.EPP01.TapaPerico.40x40cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.EPP01.TapaPerico.40x40cm; 112.AMB.Servei: URB.EP; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 1.04905 m2; 509.AMB.Volum: 0.0236704 m3
Name (AMB.TapaAdaptativaArquetaElectricitat:AMB.EPP01.TapaPerico.40x40cm:...) | 119.AMB.FaseCreacio
2974718 | Fase 1
2974881 | Fase 1
2975185 | Fase 2
3130471 | Fase 2
3130574 | Fase 2
3130651 | Fase 2
3130695 | Fase 2
3130792 | Fase 2
3130950 | Fase 2
3131056 | Fase 2
3131186 | Fase 2
3131264 | Fase 2
3131376 | Fase 2
3131451 | Fase 2
3131485 | Fase 2
3132127 | Fase 1
3132602 | Fase 1
3132809 | Fase 1
3132831 | Fase 1
3132942 | Fase 1
3132966 | Fase 1
3132989 | Fase 1
3133026 | Fase 1
3133048 | Fase 1
3133081 | Fase 1
3133114 | Fase 1
3133145 | Fase 1
3133171 | Fase 1
3133196 | Fase 1
3133210 | Fase 1
3133240 | Fase 1
3133266 | Fase 1
3133311 | Fase 2
3133344 | Fase 2
3133375 | Fase 2
3133441 | Fase 2
3133635 | Fase 2

# IfcDistributionChamberElement: AMB.TapaAdaptativaArquetaReg:AMB.XRE02.TapaPericoNetejaReg.40x40cm (4)
In: P0
Type - Classification: 70.40.20.30 Arquetes de reg (Default Classification); Material: AMB.Metall.Acer.Lacat.Negre
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.30: Arquetes de reg; 104.AMB.ClassificacioCodi: 70.40.20.30; 105.AMB.ClassificacioDescripcio: Arquetes de reg; 109.AMB.CodiTipus: XRE02; 111.AMB.DescripcioTipus: Tapa pericó neteja reg 40x40
Classification: 70.40.20.30 Arquetes de reg (Default Classification); 70.40.20.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.TapaAdaptativaArquetaReg:AMB.XRE02.TapaPericoNetejaReg.40x40cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRE02.TapaPericoNetejaReg.40x40cm; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 1.04905 m2; 509.AMB.Volum: 0.0236704 m3
Name (AMB.TapaAdaptativaArquetaReg:AMB.XRE02.TapaPericoNetejaReg.40x40cm:...) | 112.AMB.Servei | 119.AMB.FaseCreacio
3024597 | IF.FONT.RegSecundari | Fase 1
3135124 | IF.FONT.RegSecundari | Fase 2
3135891 | IF.FONT.RegSecundari | Fase 1
3139778 | IF.FONT.RegPrimari | Fase 2

# IfcDistributionChamberElement: AMB.TapaAdaptativaArquetaReg:AMB.XRE04.TapaPericoValvulaBuidatReg.40x40cm (2)
In: P0
Type - Classification: 70.40.20.30 Arquetes de reg (Default Classification); Material: AMB.Metall.Acer.Lacat.Negre
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.30: Arquetes de reg; 104.AMB.ClassificacioCodi: 70.40.20.30; 105.AMB.ClassificacioDescripcio: Arquetes de reg; 109.AMB.CodiTipus: XRE04; 111.AMB.DescripcioTipus: Tapa pericó vàlvula buidat reg 40x40
Classification: 70.40.20.30 Arquetes de reg (Default Classification); 70.40.20.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.TapaAdaptativaArquetaReg:AMB.XRE04.TapaPericoValvulaBuidatReg.40x40cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRE04.TapaPericoValvulaBuidatReg.40x40cm; 112.AMB.Servei: IF.FONT.RegSecundari; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 1.04905 m2; 509.AMB.Volum: 0.0236704 m3
Name (AMB.TapaAdaptativaArquetaReg:AMB.XRE04.TapaPericoValvulaBuidatReg.40x40cm:...) | 119.AMB.FaseCreacio
3135364 | Fase 2
3135426 | Fase 1

# IfcDistributionChamberElement: AMB.TapaAdaptativaArquetaReg:AMB.XRE07.TapaPericoReg.60x60cm, AMB.TapaAdaptativaArquetaReg:AMB.XRE07.TapaPericoReg.60x60cm:3035532
In: P0
Type - Classification: 70.40.20.30 Arquetes de reg (Default Classification); Material: AMB.Metall.Acer.Lacat.Negre
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.20.30: Arquetes de reg; 104.AMB.ClassificacioCodi: 70.40.20.30; 105.AMB.ClassificacioDescripcio: Arquetes de reg; 109.AMB.CodiTipus: XRE07; 111.AMB.DescripcioTipus: Tapa pericó reg 40x40
Classification: 70.40.20.30 Arquetes de reg (Default Classification); 70.40.20.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.TapaAdaptativaArquetaReg:AMB.XRE07.TapaPericoReg.60x60cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.XRE07.TapaPericoReg.60x60cm; 112.AMB.Servei: IF.FONT.RegPrimari; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Fase 2
5 AMB.Geometria - 507.AMB.Area: 1.51356 m2; 509.AMB.Volum: 0.0296704 m3

# IfcDistributionChamberElement: AMB.TapaClavegueram.Adaptativa:AMB.CLU02.TapaCirc.70cm (5)
In: P0
Type - Classification: 70.40.30.30 Arquetes i pous de drenatge (Default Classification); Material: AMB.Metall.Acer.Lacat.Negre, <Unnamed>
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.30: Arquetes i pous de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.30; 105.AMB.ClassificacioDescripcio: Arquetes i pous de drenatge; 109.AMB.CodiTipus: CLU02; 111.AMB.DescripcioTipus: Tapa i marc de pou, abatible de diametre 70cm
Classification: 70.40.30.30 Arquetes i pous de drenatge (Default Classification); 70.40.30.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.TapaClavegueram.Adaptativa:AMB.CLU02.TapaCirc.70cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU02.TapaCirc.70cm; 112.AMB.Servei: URB.DRE.General; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 1.47916 m2; 509.AMB.Volum: 0.0371445 m3
Name (AMB.TapaClavegueram.Adaptativa:AMB.CLU02.TapaCirc.70cm:...) | 119.AMB.FaseCreacio
3119182 | Fase 1
3119322 | Fase 1
3119473 | Fase 1
3125686 | Fase 2
3125809 | Fase 2

# IfcDistributionChamberElement: AMB.TapaClavegueram.Adaptativa:AMB.CLU07.TapaCirc.100cm (17)
In: P0
Type - Classification: 70.40.30.30 Arquetes i pous de drenatge (Default Classification); Material: AMB.Metall.Acer.Lacat.Negre, <Unnamed>
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.30: Arquetes i pous de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.30; 105.AMB.ClassificacioDescripcio: Arquetes i pous de drenatge; 109.AMB.CodiTipus: CLU07; 111.AMB.DescripcioTipus: Tapa i marc de pou, abatible de diametre 100cm
Classification: 70.40.30.30 Arquetes i pous de drenatge (Default Classification); 70.40.30.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.TapaClavegueram.Adaptativa:AMB.CLU07.TapaCirc.100cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU07.TapaCirc.100cm; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 2.12872 m2; 509.AMB.Volum: 0.0571341 m3
Name (AMB.TapaClavegueram.Adaptativa:AMB.CLU07.TapaCirc.100cm:...) | 112.AMB.Servei | 119.AMB.FaseCreacio
3121186 | URB.DRE.NouCol·lector | Fase 1
3121354 | URB.DRE.NouCol·lector | Fase 1
3121520 | URB.DRE.General | Preexistència
3121592 | URB.DRE.General | Preexistència
3121673 | URB.DRE.General | Preexistència
3121770 | URB.DRE.General | Preexistència
3121878 | URB.DRE.General | Preexistència
3121926 | URB.DRE.General | Preexistència
3121973 | URB.DRE.General | Preexistència
3325363 | URB.DRE.NouCol·lector | Fase 1
3350110 | URB.DRE.NouCol·lector | Fase 1
3355506 | URB.DRE.General | Preexistència
3360120 | URB.DRE.General | Preexistència
3360685 | URB.DRE.General | Preexistència
3366222 | URB.DRE.General | Preexistència
3370250 | URB.DRE.General | Preexistència
3371490 | URB.DRE.NouCol·lector | Fase 1

# IfcDistributionChamberElement: AMB.URB.ReixaAdaptativaMar:AMB.CLU05.Reixa.30x70cm (54)
In: P0
Type - Classification: 70.40.30.20 Reixes i buneras (Default Classification); Material: AMB.Metall.Acer.Lacat.Negre
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.20: Reixes i buneras; 104.AMB.ClassificacioCodi: 70.40.30.20; 105.AMB.ClassificacioDescripcio: Reixes i buneras; 109.AMB.CodiTipus: CLU05; 111.AMB.DescripcioTipus: Bastiment i reixa per a embornal de 70x30
Classification: 70.40.30.20 Reixes i buneras (Default Classification); 70.40.30.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.URB.ReixaAdaptativaMar:AMB.CLU05.Reixa.30x70cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLU05.Reixa.30x70cm; 112.AMB.Servei: URB.DRE.Embornal; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 0.908492 m2; 509.AMB.Volum: 0.0152839 m3
Name (AMB.URB.ReixaAdaptativaMar:AMB.CLU05.Reixa.30x70cm:...) | 119.AMB.FaseCreacio
2607666 | Fase 1
2662083 | Fase 1
3076149 | Fase 2
3090606 | Fase 1
3124580 | Fase 2
3124733 | Fase 2
3124848 | Fase 2
3124995 | Fase 2
3125332 | Fase 2
3125496 | Fase 2
3125648 | Fase 2
3126820 | Fase 2
3127006 | Fase 2
3127033 | Fase 2
3127307 | Fase 2
3127525 | Fase 1
3127628 | Fase 1
3127645 | Fase 1
3127895 | Fase 1
3128121 | Fase 1
3128303 | Fase 1
3242248 | Fase 1
3352863 | Fase 1
3352990 | Fase 1
3353159 | Fase 1
3353474 | Fase 1
3353607 | Fase 1
3353860 | Fase 1
3354328 | Fase 1
3355179 | Fase 1
3356485 | Fase 2
3356726 | Fase 2
3357154 | Fase 2
3358684 | Fase 2
3361740 | Fase 2
3361883 | Fase 2
3367021 | Fase 1
3367213 | Fase 1
3367410 | Fase 1
3367612 | Fase 1
3367707 | Fase 1
3367767 | Fase 1
3367827 | Fase 1
3367916 | Fase 1
3368056 | Fase 1
3368173 | Fase 1
3368305 | Fase 2
3368534 | Fase 2
3368621 | Fase 2
3368682 | Fase 2
3368854 | Fase 2
3369057 | Fase 2
3369134 | Fase 2
3369172 | Fase 2

# IfcDistributionPort (1448)
Description: Flow
Name | FlowDirection | Group
Port_2583072_0 | SOURCEANDSINK | URB.DRE.Embornal 1
Port_2583072_1 | SOURCEANDSINK | URB.DRE.Embornal 1
Port_2606344_1 | SOURCEANDSINK
Port_2606344_2 | SOURCEANDSINK
Port_2606344_3 | SOURCEANDSINK
Port_2606344_4 | SOURCEANDSINK
Port_2606344_5 | SOURCEANDSINK
Port_2606344_6 | SOURCEANDSINK
Port_2606344_7 | SOURCEANDSINK
Port_2606344_8 | SOURCEANDSINK
Port_2607856_0 | SOURCEANDSINK | URB.DRE.Embornal 7
Port_2607856_1 | SOURCEANDSINK | URB.DRE.Embornal 7
Port_2608396_0 | SOURCEANDSINK | URB.DRE.Embornal 9
Port_2608396_1 | SOURCEANDSINK | URB.DRE.Embornal 9
Port_2608561_1 | SOURCEANDSINK
Port_2608561_2 | SOURCEANDSINK
Port_2608561_3 | SOURCEANDSINK
Port_2608561_4 | SOURCEANDSINK
Port_2608561_5 | SOURCEANDSINK
Port_2608561_6 | SOURCEANDSINK
Port_2608561_7 | SOURCEANDSINK
Port_2608561_8 | SOURCEANDSINK
Port_2608831_0 | SOURCEANDSINK | URB.DRE.Embornal 11
Port_2608831_1 | SOURCEANDSINK | URB.DRE.Embornal 11
Port_2633400_0 | SOURCEANDSINK | URB.DRE.Embornal 13
Port_2633400_1 | SOURCEANDSINK | URB.DRE.Embornal 13
Port_2633554_0 | SOURCEANDSINK | URB.DRE.Embornal 15
Port_2633554_1 | SOURCEANDSINK | URB.DRE.Embornal 15
Port_2633774_0 | SOURCEANDSINK | URB.DRE.Embornal 19
Port_2633774_1 | SOURCEANDSINK | URB.DRE.Embornal 19
Port_2633822_0 | SOURCEANDSINK | URB.DRE.Embornal 21
Port_2633822_1 | SOURCEANDSINK | URB.DRE.Embornal 21
Port_2633908_0 | SOURCEANDSINK | URB.DRE.Embornal 23
Port_2633908_1 | SOURCEANDSINK | URB.DRE.Embornal 23
Port_2633990_0 | SOURCEANDSINK | URB.DRE.Embornal 25
Port_2633990_1 | SOURCEANDSINK | URB.DRE.Embornal 25
Port_2634259_0 | SOURCEANDSINK | URB.DRE.Embornal 27
Port_2634259_1 | SOURCEANDSINK | URB.DRE.Embornal 27
Port_2634388_0 | SOURCEANDSINK | URB.DRE.Embornal 29
Port_2634388_1 | SOURCEANDSINK | URB.DRE.Embornal 29
Port_2635523_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3354114_2 | SOURCEANDSINK | URB.DRE.General 3
Port_2635523_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3079100_2 | SOURCEANDSINK | URB.DRE.General 3
Port_2637143_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3052166_2 | SOURCEANDSINK | URB.DRE.General 3
Port_2637143_1 | SOURCEANDSINK | URB.DRE.General 3
Port_3051226_1 | SOURCEANDSINK | URB.DRE.General 3
InPort_2637143_2 | SINK | URB.DRE.General 3
OutPort_3355466_1 | SOURCE | URB.DRE.General 3
Port_2662464_0 | SOURCEANDSINK | URB.DRE.Embornal 31
Port_2662464_1 | SOURCEANDSINK | URB.DRE.Embornal 31
Port_2662479_0 | SOURCEANDSINK | URB.DRE.Embornal 31
Port_2662479_1 | SOURCEANDSINK | URB.DRE.Embornal 31
Port_2662483_1 | SOURCEANDSINK | URB.DRE.Embornal 31
Port_2662483_2 | SOURCEANDSINK | URB.DRE.Embornal 31
Port_2667557_0 | SOURCEANDSINK | URB.DRE.Embornal 36
Port_2667557_1 | SOURCEANDSINK | URB.DRE.Embornal 36
Port_2671214_0 | SOURCEANDSINK | URB.DRE.General 3
Port_3078954_2 | SOURCEANDSINK | URB.DRE.General 3
Port_2671214_1 | SOURCEANDSINK | URB.DRE.General 3
OutPort_2757909_1 | SOURCE | URB.EP 4
OutPort_2757909_2 | SOURCE | URB.EP 4
OutPort_2757909_3 | SOURCE | URB.EP 4
OutPort_2757909_4 | SOURCE | URB.EP 4
OutPort_2757909_5 | SOURCE | URB.EP 4
OutPort_2757909_6 | SOURCE | URB.EP 4
OutPort_2757909_7 | SOURCE | URB.EP 4
OutPort_2757909_8 | SOURCE | URB.EP 4
OutPort_2757909_9 | SOURCE | URB.EP 4
OutPort_2757909_10 | SOURCE | URB.EP 4
OutPort_2757909_11 | SOURCE | URB.EP 4
OutPort_2757909_13 | SOURCE | URB.EP 4
OutPort_2757909_14 | SOURCE | URB.EP 4
OutPort_2757909_15 | SOURCE | URB.EP 4
OutPort_2757909_16 | SOURCE | URB.EP 4
Port_2757909_17 | SOURCEANDSINK
Port_2757909_18 | SOURCEANDSINK
Port_2757909_19 | SOURCEANDSINK
Port_2757909_20 | SOURCEANDSINK
OutPort_2926599_1 | SOURCE | URB.EP 4
OutPort_2926599_2 | SOURCE | URB.EP 4
OutPort_2926599_3 | SOURCE | URB.EP 4
OutPort_2926599_4 | SOURCE | URB.EP 4
OutPort_2926599_5 | SOURCE | URB.EP 4
OutPort_2926599_6 | SOURCE | URB.EP 4
OutPort_2926599_7 | SOURCE | URB.EP 4
OutPort_2926599_8 | SOURCE | URB.EP 4
OutPort_2926599_9 | SOURCE | URB.EP 4
OutPort_2926599_10 | SOURCE | URB.EP 4
OutPort_2926599_12 | SOURCE | URB.EP 4
OutPort_2926599_13 | SOURCE | URB.EP 4
OutPort_2926599_14 | SOURCE | URB.EP 4
OutPort_2926599_15 | SOURCE | URB.EP 4
OutPort_2926599_16 | SOURCE | URB.EP 4
Port_2926599_17 | SOURCEANDSINK
Port_2926599_18 | SOURCEANDSINK
Port_2926599_19 | SOURCEANDSINK
Port_2926599_20 | SOURCEANDSINK
OutPort_2926812_1 | SOURCE | URB.EP 4
OutPort_2926812_2 | SOURCE | URB.EP 4
OutPort_2926812_3 | SOURCE | URB.EP 4
OutPort_2926812_4 | SOURCE | URB.EP 4
OutPort_2926812_5 | SOURCE | URB.EP 4
OutPort_2926812_6 | SOURCE | URB.EP 4
OutPort_2926812_7 | SOURCE | URB.EP 4
OutPort_2926812_8 | SOURCE | URB.EP 4
OutPort_2926812_9 | SOURCE | URB.EP 4
OutPort_2926812_10 | SOURCE | URB.EP 4
OutPort_2926812_12 | SOURCE | URB.EP 4
OutPort_2926812_13 | SOURCE | URB.EP 4
OutPort_2926812_14 | SOURCE | URB.EP 4
OutPort_2926812_15 | SOURCE | URB.EP 4
OutPort_2926812_16 | SOURCE | URB.EP 4
Port_2926812_17 | SOURCEANDSINK
Port_2926812_18 | SOURCEANDSINK
Port_2926812_19 | SOURCEANDSINK
Port_2926812_20 | SOURCEANDSINK
OutPort_2927052_1 | SOURCE | URB.EP 4
OutPort_2927052_2 | SOURCE | URB.EP 4
OutPort_2927052_3 | SOURCE | URB.EP 4
OutPort_2927052_4 | SOURCE | URB.EP 4
OutPort_2927052_5 | SOURCE | URB.EP 4
OutPort_2927052_6 | SOURCE | URB.EP 4
OutPort_2927052_7 | SOURCE | URB.EP 4
OutPort_2927052_8 | SOURCE | URB.EP 4
OutPort_2927052_9 | SOURCE | URB.EP 4
OutPort_2927052_10 | SOURCE | URB.EP 4
OutPort_2927052_11 | SOURCE | URB.EP 4
OutPort_2927052_12 | SOURCE | URB.EP 4
OutPort_2927052_13 | SOURCE | URB.EP 4
OutPort_2927052_14 | SOURCE | URB.EP 4
OutPort_2927052_15 | SOURCE | URB.EP 4
Port_2927052_17 | SOURCEANDSINK
Port_2927052_18 | SOURCEANDSINK
Port_2927052_19 | SOURCEANDSINK
Port_2927052_20 | SOURCEANDSINK
OutPort_2927220_1 | SOURCE | URB.EP 4
OutPort_2927220_2 | SOURCE | URB.EP 4
OutPort_2927220_3 | SOURCE | URB.EP 4
OutPort_2927220_4 | SOURCE | URB.EP 4
OutPort_2927220_5 | SOURCE | URB.EP 4
OutPort_2927220_6 | SOURCE | URB.EP 4
OutPort_2927220_7 | SOURCE | URB.EP 4
OutPort_2927220_8 | SOURCE | URB.EP 4
OutPort_2927220_9 | SOURCE | URB.EP 4
OutPort_2927220_10 | SOURCE | URB.EP 4
OutPort_2927220_11 | SOURCE | URB.EP 4
OutPort_2927220_12 | SOURCE | URB.EP 4
OutPort_2927220_13 | SOURCE | URB.EP 4
OutPort_2927220_14 | SOURCE | URB.EP 4
OutPort_2927220_15 | SOURCE | URB.EP 4
Port_2927220_17 | SOURCEANDSINK
Port_2927220_18 | SOURCEANDSINK
Port_2927220_19 | SOURCEANDSINK
Port_2927220_20 | SOURCEANDSINK
OutPort_2927485_1 | SOURCE | URB.EP 4
OutPort_2927485_2 | SOURCE | URB.EP 4
OutPort_2927485_3 | SOURCE | URB.EP 4
OutPort_2927485_4 | SOURCE | URB.EP 4
OutPort_2927485_5 | SOURCE | URB.EP 4
OutPort_2927485_6 | SOURCE | URB.EP 4
OutPort_2927485_7 | SOURCE | URB.EP 4
OutPort_2927485_8 | SOURCE | URB.EP 4
OutPort_2927485_9 | SOURCE | URB.EP 4
OutPort_2927485_10 | SOURCE | URB.EP 4
OutPort_2927485_11 | SOURCE | URB.EP 4
OutPort_2927485_12 | SOURCE | URB.EP 4
OutPort_2927485_13 | SOURCE | URB.EP 4
OutPort_2927485_15 | SOURCE | URB.EP 4
OutPort_2927485_16 | SOURCE | URB.EP 4
Port_2927485_17 | SOURCEANDSINK
Port_2927485_18 | SOURCEANDSINK
Port_2927485_19 | SOURCEANDSINK
Port_2927485_20 | SOURCEANDSINK
OutPort_2927655_1 | SOURCE | URB.EP 4
OutPort_2927655_2 | SOURCE | URB.EP 4
OutPort_2927655_3 | SOURCE | URB.EP 4
OutPort_2927655_4 | SOURCE | URB.EP 4
OutPort_2927655_5 | SOURCE | URB.EP 4
OutPort_2927655_6 | SOURCE | URB.EP 4
OutPort_2927655_7 | SOURCE | URB.EP 4
OutPort_2927655_8 | SOURCE | URB.EP 4
OutPort_2927655_9 | SOURCE | URB.EP 4
OutPort_2927655_10 | SOURCE | URB.EP 4
OutPort_2927655_11 | SOURCE | URB.EP 4
OutPort_2927655_12 | SOURCE | URB.EP 4
OutPort_2927655_13 | SOURCE | URB.EP 4
OutPort_2927655_15 | SOURCE | URB.EP 4
OutPort_2927655_16 | SOURCE | URB.EP 4
Port_2927655_17 | SOURCEANDSINK
Port_2927655_18 | SOURCEANDSINK
Port_2927655_19 | SOURCEANDSINK
Port_2927655_20 | SOURCEANDSINK
OutPort_2927877_1 | SOURCE | URB.EP 4
OutPort_2927877_2 | SOURCE | URB.EP 4
OutPort_2927877_3 | SOURCE | URB.EP 4
OutPort_2927877_4 | SOURCE | URB.EP 4
OutPort_2927877_5 | SOURCE | URB.EP 4
OutPort_2927877_6 | SOURCE | URB.EP 4
OutPort_2927877_7 | SOURCE | URB.EP 4
OutPort_2927877_8 | SOURCE | URB.EP 4
OutPort_2927877_9 | SOURCE | URB.EP 4
OutPort_2927877_10 | SOURCE | URB.EP 4
OutPort_2927877_11 | SOURCE | URB.EP 4
OutPort_2927877_13 | SOURCE | URB.EP 4
OutPort_2927877_14 | SOURCE | URB.EP 4
OutPort_2927877_15 | SOURCE | URB.EP 4
OutPort_2927877_16 | SOURCE | URB.EP 4
Port_2927877_17 | SOURCEANDSINK
Port_2927877_18 | SOURCEANDSINK
Port_2927877_19 | SOURCEANDSINK
Port_2927877_20 | SOURCEANDSINK
OutPort_2928132_1 | SOURCE | URB.EP 4
OutPort_2928132_2 | SOURCE | URB.EP 4
OutPort_2928132_3 | SOURCE | URB.EP 4
OutPort_2928132_4 | SOURCE | URB.EP 4
OutPort_2928132_5 | SOURCE | URB.EP 4
OutPort_2928132_6 | SOURCE | URB.EP 4
OutPort_2928132_7 | SOURCE | URB.EP 4
OutPort_2928132_8 | SOURCE | URB.EP 4
OutPort_2928132_9 | SOURCE | URB.EP 4
OutPort_2928132_10 | SOURCE | URB.EP 4
OutPort_2928132_11 | SOURCE | URB.EP 4
OutPort_2928132_13 | SOURCE | URB.EP 4
OutPort_2928132_14 | SOURCE | URB.EP 4
OutPort_2928132_15 | SOURCE | URB.EP 4
OutPort_2928132_16 | SOURCE | URB.EP 4
Port_2928132_17 | SOURCEANDSINK
Port_2928132_18 | SOURCEANDSINK
Port_2928132_19 | SOURCEANDSINK
Port_2928132_20 | SOURCEANDSINK
OutPort_2928300_1 | SOURCE | URB.EP 4
OutPort_2928300_2 | SOURCE | URB.EP 4
OutPort_2928300_3 | SOURCE | URB.EP 4
OutPort_2928300_4 | SOURCE | URB.EP 4
OutPort_2928300_5 | SOURCE | URB.EP 4
OutPort_2928300_6 | SOURCE | URB.EP 4
OutPort_2928300_7 | SOURCE | URB.EP 4
OutPort_2928300_8 | SOURCE | URB.EP 4
OutPort_2928300_9 | SOURCE | URB.EP 4
OutPort_2928300_10 | SOURCE | URB.EP 4
OutPort_2928300_11 | SOURCE | URB.EP 4
OutPort_2928300_13 | SOURCE | URB.EP 4
OutPort_2928300_14 | SOURCE | URB.EP 4
OutPort_2928300_15 | SOURCE | URB.EP 4
OutPort_2928300_16 | SOURCE | URB.EP 4
Port_2928300_17 | SOURCEANDSINK
Port_2928300_18 | SOURCEANDSINK
Port_2928300_19 | SOURCEANDSINK
Port_2928300_20 | SOURCEANDSINK
OutPort_2928450_1 | SOURCE | URB.EP 4
OutPort_2928450_2 | SOURCE | URB.EP 4
OutPort_2928450_3 | SOURCE | URB.EP 4
OutPort_2928450_4 | SOURCE | URB.EP 4
OutPort_2928450_5 | SOURCE | URB.EP 4
OutPort_2928450_6 | SOURCE | URB.EP 4
OutPort_2928450_7 | SOURCE | URB.EP 4
OutPort_2928450_8 | SOURCE | URB.EP 4
OutPort_2928450_9 | SOURCE | URB.EP 4
OutPort_2928450_10 | SOURCE | URB.EP 4
OutPort_2928450_11 | SOURCE | URB.EP 4
OutPort_2928450_13 | SOURCE | URB.EP 4
OutPort_2928450_14 | SOURCE | URB.EP 4
OutPort_2928450_15 | SOURCE | URB.EP 4
OutPort_2928450_16 | SOURCE | URB.EP 4
Port_2928450_17 | SOURCEANDSINK
Port_2928450_18 | SOURCEANDSINK
Port_2928450_19 | SOURCEANDSINK
Port_2928450_20 | SOURCEANDSINK
OutPort_2928669_1 | SOURCE | URB.EP 4
OutPort_2928669_2 | SOURCE | URB.EP 4
OutPort_2928669_3 | SOURCE | URB.EP 4
OutPort_2928669_4 | SOURCE | URB.EP 4
OutPort_2928669_5 | SOURCE | URB.EP 4
OutPort_2928669_6 | SOURCE | URB.EP 4
OutPort_2928669_7 | SOURCE | URB.EP 4
OutPort_2928669_8 | SOURCE | URB.EP 4
OutPort_2928669_9 | SOURCE | URB.EP 4
OutPort_2928669_10 | SOURCE | URB.EP 4
OutPort_2928669_11 | SOURCE | URB.EP 4
OutPort_2928669_13 | SOURCE | URB.EP 4
OutPort_2928669_14 | SOURCE | URB.EP 4
OutPort_2928669_15 | SOURCE | URB.EP 4
OutPort_2928669_16 | SOURCE | URB.EP 4
Port_2928669_17 | SOURCEANDSINK
Port_2928669_18 | SOURCEANDSINK
Port_2928669_19 | SOURCEANDSINK
Port_2928669_20 | SOURCEANDSINK
OutPort_2928894_1 | SOURCE | URB.EP 4
OutPort_2928894_3 | SOURCE | URB.EP 4
OutPort_2928894_4 | SOURCE | URB.EP 4
OutPort_2928894_5 | SOURCE | URB.EP 4
OutPort_2928894_6 | SOURCE | URB.EP 4
OutPort_2928894_7 | SOURCE | URB.EP 4
OutPort_2928894_8 | SOURCE | URB.EP 4
OutPort_2928894_9 | SOURCE | URB.EP 4
OutPort_2928894_10 | SOURCE | URB.EP 4
OutPort_2928894_11 | SOURCE | URB.EP 4
OutPort_2928894_12 | SOURCE | URB.EP 4
OutPort_2928894_13 | SOURCE | URB.EP 4
OutPort_2928894_14 | SOURCE | URB.EP 4
OutPort_2928894_15 | SOURCE | URB.EP 4
OutPort_2928894_16 | SOURCE | URB.EP 4
Port_2928894_17 | SOURCEANDSINK
Port_2928894_18 | SOURCEANDSINK
Port_2928894_19 | SOURCEANDSINK
Port_2928894_20 | SOURCEANDSINK
OutPort_2929009_1 | SOURCE | URB.EP 4
OutPort_2929009_2 | SOURCE | URB.EP 4
OutPort_2929009_3 | SOURCE | URB.EP 4
OutPort_2929009_4 | SOURCE | URB.EP 4
OutPort_2929009_5 | SOURCE | URB.EP 4
OutPort_2929009_6 | SOURCE | URB.EP 4
OutPort_2929009_7 | SOURCE | URB.EP 4
OutPort_2929009_8 | SOURCE | URB.EP 4
OutPort_2929009_9 | SOURCE | URB.EP 4
OutPort_2929009_10 | SOURCE | URB.EP 4
OutPort_2929009_11 | SOURCE | URB.EP 4
OutPort_2929009_13 | SOURCE | URB.EP 4
OutPort_2929009_14 | SOURCE | URB.EP 4
OutPort_2929009_15 | SOURCE | URB.EP 4
OutPort_2929009_16 | SOURCE | URB.EP 4
Port_2929009_17 | SOURCEANDSINK
Port_2929009_18 | SOURCEANDSINK
Port_2929009_19 | SOURCEANDSINK
Port_2929009_20 | SOURCEANDSINK
OutPort_2929310_1 | SOURCE | URB.EP 5
OutPort_2929310_2 | SOURCE | URB.EP 5
OutPort_2929310_3 | SOURCE | URB.EP 5
Port_2929310_4 | SOURCEANDSINK | URB.EP 5
Port_2989973_1 | SOURCEANDSINK | URB.EP 5
OutPort_2929310_5 | SOURCE | URB.EP 5
OutPort_2929310_6 | SOURCE | URB.EP 5
OutPort_2929310_7 | SOURCE | URB.EP 5
OutPort_2929310_8 | SOURCE | URB.EP 5
OutPort_2929310_9 | SOURCE | URB.EP 5
OutPort_2929310_10 | SOURCE | URB.EP 5
OutPort_2929310_11 | SOURCE | URB.EP 5
OutPort_2929310_12 | SOURCE | URB.EP 5
OutPort_2929310_13 | SOURCE | URB.EP 5
OutPort_2929310_14 | SOURCE | URB.EP 5
OutPort_2929310_15 | SOURCE | URB.EP 5
OutPort_2929310_16 | SOURCE | URB.EP 5
Port_2929310_17 | SOURCEANDSINK
Port_2929310_18 | SOURCEANDSINK
Port_2929310_19 | SOURCEANDSINK
Port_2929310_20 | SOURCEANDSINK
OutPort_2929400_1 | SOURCE | URB.EP 4
OutPort_2929400_2 | SOURCE | URB.EP 4
OutPort_2929400_3 | SOURCE | URB.EP 4
OutPort_2929400_4 | SOURCE | URB.EP 4
OutPort_2929400_5 | SOURCE | URB.EP 4
OutPort_2929400_6 | SOURCE | URB.EP 4
OutPort_2929400_7 | SOURCE | URB.EP 4
OutPort_2929400_8 | SOURCE | URB.EP 4
OutPort_2929400_9 | SOURCE | URB.EP 4
OutPort_2929400_10 | SOURCE | URB.EP 4
OutPort_2929400_11 | SOURCE | URB.EP 4
OutPort_2929400_13 | SOURCE | URB.EP 4
OutPort_2929400_14 | SOURCE | URB.EP 4
OutPort_2929400_15 | SOURCE | URB.EP 4
OutPort_2929400_16 | SOURCE | URB.EP 4
Port_2929400_17 | SOURCEANDSINK
Port_2929400_18 | SOURCEANDSINK
Port_2929400_19 | SOURCEANDSINK
Port_2929400_20 | SOURCEANDSINK
OutPort_2929444_1 | SOURCE | URB.EP 4
OutPort_2929444_2 | SOURCE | URB.EP 4
OutPort_2929444_3 | SOURCE | URB.EP 4
OutPort_2929444_4 | SOURCE | URB.EP 4
OutPort_2929444_5 | SOURCE | URB.EP 4
OutPort_2929444_6 | SOURCE | URB.EP 4
OutPort_2929444_7 | SOURCE | URB.EP 4
OutPort_2929444_8 | SOURCE | URB.EP 4
OutPort_2929444_9 | SOURCE | URB.EP 4
OutPort_2929444_10 | SOURCE | URB.EP 4
OutPort_2929444_12 | SOURCE | URB.EP 4
OutPort_2929444_13 | SOURCE | URB.EP 4
OutPort_2929444_14 | SOURCE | URB.EP 4
OutPort_2929444_15 | SOURCE | URB.EP 4
OutPort_2929444_16 | SOURCE | URB.EP 4
Port_2929444_17 | SOURCEANDSINK
Port_2929444_18 | SOURCEANDSINK
Port_2929444_19 | SOURCEANDSINK
Port_2929444_20 | SOURCEANDSINK
OutPort_2929669_1 | SOURCE | URB.EP 4
OutPort_2929669_2 | SOURCE | URB.EP 4
OutPort_2929669_3 | SOURCE | URB.EP 4
OutPort_2929669_4 | SOURCE | URB.EP 4
OutPort_2929669_5 | SOURCE | URB.EP 4
OutPort_2929669_6 | SOURCE | URB.EP 4
OutPort_2929669_7 | SOURCE | URB.EP 4
OutPort_2929669_8 | SOURCE | URB.EP 4
OutPort_2929669_9 | SOURCE | URB.EP 4
OutPort_2929669_10 | SOURCE | URB.EP 4
OutPort_2929669_11 | SOURCE | URB.EP 4
OutPort_2929669_13 | SOURCE | URB.EP 4
OutPort_2929669_14 | SOURCE | URB.EP 4
OutPort_2929669_15 | SOURCE | URB.EP 4
OutPort_2929669_16 | SOURCE | URB.EP 4
Port_2929669_17 | SOURCEANDSINK
Port_2929669_18 | SOURCEANDSINK
Port_2929669_19 | SOURCEANDSINK
Port_2929669_20 | SOURCEANDSINK
OutPort_2929966_1 | SOURCE | URB.EP 4
OutPort_2929966_2 | SOURCE | URB.EP 4
OutPort_2929966_3 | SOURCE | URB.EP 4
OutPort_2929966_4 | SOURCE | URB.EP 4
OutPort_2929966_5 | SOURCE | URB.EP 4
OutPort_2929966_6 | SOURCE | URB.EP 4
OutPort_2929966_7 | SOURCE | URB.EP 4
OutPort_2929966_8 | SOURCE | URB.EP 4
OutPort_2929966_9 | SOURCE | URB.EP 4
OutPort_2929966_10 | SOURCE | URB.EP 4
OutPort_2929966_11 | SOURCE | URB.EP 4
OutPort_2929966_13 | SOURCE | URB.EP 4
OutPort_2929966_14 | SOURCE | URB.EP 4
OutPort_2929966_15 | SOURCE | URB.EP 4
OutPort_2929966_16 | SOURCE | URB.EP 4
Port_2929966_17 | SOURCEANDSINK
Port_2929966_18 | SOURCEANDSINK
Port_2929966_19 | SOURCEANDSINK
Port_2929966_20 | SOURCEANDSINK
OutPort_2930042_1 | SOURCE | URB.EP 4
OutPort_2930042_2 | SOURCE | URB.EP 4
OutPort_2930042_3 | SOURCE | URB.EP 4
OutPort_2930042_4 | SOURCE | URB.EP 4
OutPort_2930042_5 | SOURCE | URB.EP 4
OutPort_2930042_6 | SOURCE | URB.EP 4
OutPort_2930042_7 | SOURCE | URB.EP 4
OutPort_2930042_8 | SOURCE | URB.EP 4
OutPort_2930042_9 | SOURCE | URB.EP 4
OutPort_2930042_10 | SOURCE | URB.EP 4
OutPort_2930042_12 | SOURCE | URB.EP 4
OutPort_2930042_13 | SOURCE | URB.EP 4
OutPort_2930042_14 | SOURCE | URB.EP 4
OutPort_2930042_15 | SOURCE | URB.EP 4
OutPort_2930042_16 | SOURCE | URB.EP 4
Port_2930042_17 | SOURCEANDSINK
Port_2930042_18 | SOURCEANDSINK
Port_2930042_19 | SOURCEANDSINK
Port_2930042_20 | SOURCEANDSINK
OutPort_2930094_1 | SOURCE | URB.EP 4
OutPort_2930094_2 | SOURCE | URB.EP 4
OutPort_2930094_3 | SOURCE | URB.EP 4
OutPort_2930094_4 | SOURCE | URB.EP 4
OutPort_2930094_5 | SOURCE | URB.EP 4
OutPort_2930094_6 | SOURCE | URB.EP 4
OutPort_2930094_7 | SOURCE | URB.EP 4
OutPort_2930094_8 | SOURCE | URB.EP 4
OutPort_2930094_9 | SOURCE | URB.EP 4
OutPort_2930094_10 | SOURCE | URB.EP 4
OutPort_2930094_12 | SOURCE | URB.EP 4
OutPort_2930094_13 | SOURCE | URB.EP 4
OutPort_2930094_14 | SOURCE | URB.EP 4
OutPort_2930094_15 | SOURCE | URB.EP 4
OutPort_2930094_16 | SOURCE | URB.EP 4
Port_2930094_17 | SOURCEANDSINK
Port_2930094_18 | SOURCEANDSINK
Port_2930094_19 | SOURCEANDSINK
Port_2930094_20 | SOURCEANDSINK
OutPort_2930267_1 | SOURCE | URB.EP 4
OutPort_2930267_2 | SOURCE | URB.EP 4
OutPort_2930267_3 | SOURCE | URB.EP 4
OutPort_2930267_4 | SOURCE | URB.EP 4
OutPort_2930267_5 | SOURCE | URB.EP 4
OutPort_2930267_6 | SOURCE | URB.EP 4
OutPort_2930267_7 | SOURCE | URB.EP 4
OutPort_2930267_8 | SOURCE | URB.EP 4
OutPort_2930267_9 | SOURCE | URB.EP 4
OutPort_2930267_10 | SOURCE | URB.EP 4
OutPort_2930267_11 | SOURCE | URB.EP 4
OutPort_2930267_13 | SOURCE | URB.EP 4
OutPort_2930267_14 | SOURCE | URB.EP 4
OutPort_2930267_15 | SOURCE | URB.EP 4
OutPort_2930267_16 | SOURCE | URB.EP 4
Port_2930267_17 | SOURCEANDSINK
Port_2930267_18 | SOURCEANDSINK
Port_2930267_19 | SOURCEANDSINK
Port_2930267_20 | SOURCEANDSINK
OutPort_2930454_1 | SOURCE | URB.EP 4
OutPort_2930454_2 | SOURCE | URB.EP 4
OutPort_2930454_3 | SOURCE | URB.EP 4
OutPort_2930454_4 | SOURCE | URB.EP 4
OutPort_2930454_5 | SOURCE | URB.EP 4
OutPort_2930454_6 | SOURCE | URB.EP 4
OutPort_2930454_7 | SOURCE | URB.EP 4
OutPort_2930454_8 | SOURCE | URB.EP 4
OutPort_2930454_9 | SOURCE | URB.EP 4
OutPort_2930454_10 | SOURCE | URB.EP 4
OutPort_2930454_11 | SOURCE | URB.EP 4
OutPort_2930454_13 | SOURCE | URB.EP 4
OutPort_2930454_14 | SOURCE | URB.EP 4
OutPort_2930454_15 | SOURCE | URB.EP 4
OutPort_2930454_16 | SOURCE | URB.EP 4
Port_2930454_17 | SOURCEANDSINK
Port_2930454_18 | SOURCEANDSINK
Port_2930454_19 | SOURCEANDSINK
Port_2930454_20 | SOURCEANDSINK
OutPort_2930719_1 | SOURCE | URB.EP 4
OutPort_2930719_2 | SOURCE | URB.EP 4
OutPort_2930719_3 | SOURCE | URB.EP 4
OutPort_2930719_4 | SOURCE | URB.EP 4
OutPort_2930719_5 | SOURCE | URB.EP 4
OutPort_2930719_6 | SOURCE | URB.EP 4
OutPort_2930719_7 | SOURCE | URB.EP 4
OutPort_2930719_8 | SOURCE | URB.EP 4
OutPort_2930719_9 | SOURCE | URB.EP 4
OutPort_2930719_10 | SOURCE | URB.EP 4
OutPort_2930719_11 | SOURCE | URB.EP 4
OutPort_2930719_12 | SOURCE | URB.EP 4
OutPort_2930719_13 | SOURCE | URB.EP 4
OutPort_2930719_14 | SOURCE | URB.EP 4
OutPort_2930719_15 | SOURCE | URB.EP 4
Port_2930719_16 | SOURCEANDSINK | URB.EP 4
Port_2989801_1 | SOURCEANDSINK | URB.EP 4
Port_2930719_17 | SOURCEANDSINK
Port_2930719_18 | SOURCEANDSINK
Port_2930719_19 | SOURCEANDSINK
Port_2930719_20 | SOURCEANDSINK
OutPort_2931043_1 | SOURCE | URB.EP 4
OutPort_2931043_2 | SOURCE | URB.EP 4
OutPort_2931043_3 | SOURCE | URB.EP 4
OutPort_2931043_4 | SOURCE | URB.EP 4
OutPort_2931043_5 | SOURCE | URB.EP 4
OutPort_2931043_6 | SOURCE | URB.EP 4
OutPort_2931043_7 | SOURCE | URB.EP 4
OutPort_2931043_8 | SOURCE | URB.EP 4
OutPort_2931043_9 | SOURCE | URB.EP 4
OutPort_2931043_10 | SOURCE | URB.EP 4
OutPort_2931043_11 | SOURCE | URB.EP 4
OutPort_2931043_12 | SOURCE | URB.EP 4
OutPort_2931043_13 | SOURCE | URB.EP 4
OutPort_2931043_14 | SOURCE | URB.EP 4
OutPort_2931043_15 | SOURCE | URB.EP 4
Port_2931043_16 | SOURCEANDSINK | URB.EP 4
Port_2989814_1 | SOURCEANDSINK | URB.EP 4
Port_2931043_17 | SOURCEANDSINK
Port_2931043_18 | SOURCEANDSINK
Port_2931043_19 | SOURCEANDSINK
Port_2931043_20 | SOURCEANDSINK
OutPort_2931245_1 | SOURCE | URB.EP 3
OutPort_2931245_2 | SOURCE | URB.EP 3
OutPort_2931245_3 | SOURCE | URB.EP 3
OutPort_2931245_4 | SOURCE | URB.EP 3
OutPort_2931245_5 | SOURCE | URB.EP 3
OutPort_2931245_6 | SOURCE | URB.EP 3
OutPort_2931245_7 | SOURCE | URB.EP 3
OutPort_2931245_8 | SOURCE | URB.EP 3
OutPort_2931245_9 | SOURCE | URB.EP 3
OutPort_2931245_10 | SOURCE | URB.EP 3
OutPort_2931245_11 | SOURCE | URB.EP 3
OutPort_2931245_12 | SOURCE | URB.EP 3
OutPort_2931245_13 | SOURCE | URB.EP 3
OutPort_2931245_14 | SOURCE | URB.EP 3
Port_2931245_15 | SOURCEANDSINK | URB.EP 3
Port_2989827_1 | SOURCEANDSINK | URB.EP 3
OutPort_2931245_16 | SOURCE | URB.EP 3
Port_2931245_17 | SOURCEANDSINK
Port_2931245_18 | SOURCEANDSINK
Port_2931245_19 | SOURCEANDSINK
Port_2931245_20 | SOURCEANDSINK
OutPort_2931437_1 | SOURCE | URB.EP 7
OutPort_2931437_2 | SOURCE | URB.EP 7
OutPort_2931437_3 | SOURCE | URB.EP 7
OutPort_2931437_4 | SOURCE | URB.EP 7
OutPort_2931437_5 | SOURCE | URB.EP 7
OutPort_2931437_6 | SOURCE | URB.EP 7
OutPort_2931437_7 | SOURCE | URB.EP 7
OutPort_2931437_8 | SOURCE | URB.EP 7
OutPort_2931437_9 | SOURCE | URB.EP 7
OutPort_2931437_10 | SOURCE | URB.EP 7
OutPort_2931437_11 | SOURCE | URB.EP 7
OutPort_2931437_12 | SOURCE | URB.EP 7
OutPort_2931437_13 | SOURCE | URB.EP 7
OutPort_2931437_14 | SOURCE | URB.EP 7
Port_2931437_15 | SOURCEANDSINK | URB.EP 7
Port_2989840_1 | SOURCEANDSINK | URB.EP 7
OutPort_2931437_16 | SOURCE | URB.EP 7
Port_2931437_17 | SOURCEANDSINK
Port_2931437_18 | SOURCEANDSINK
Port_2931437_19 | SOURCEANDSINK
Port_2931437_20 | SOURCEANDSINK
Port_2965557_1 | SOURCEANDSINK | URB.EP 4
Port_2985402_0 | SOURCEANDSINK | URB.EP 4
Port_2965557_5 | SOURCEANDSINK | URB.EP 4
Port_2985390_1 | SOURCEANDSINK | URB.EP 4
OutPort_2965557_10 | SOURCE | URB.EP 4
Port_2966299_1 | SOURCEANDSINK | URB.EP 4
Port_2985458_0 | SOURCEANDSINK | URB.EP 4
OutPort_2966299_5 | SOURCE | URB.EP 4
OutPort_2966299_10 | SOURCE | URB.EP 4
Port_2966299_13 | SOURCEANDSINK | URB.EP 4
Port_2985438_1 | SOURCEANDSINK | URB.EP 4
Port_2966395_1 | SOURCEANDSINK | URB.EP 4
Port_2985474_0 | SOURCEANDSINK | URB.EP 4
Port_2966395_5 | SOURCEANDSINK | URB.EP 4
Port_2985458_1 | SOURCEANDSINK | URB.EP 4
OutPort_2966395_10 | SOURCE | URB.EP 4
OutPort_2966395_13 | SOURCE | URB.EP 4
OutPort_2966489_1 | SOURCE | URB.EP 4
OutPort_2966489_5 | SOURCE | URB.EP 4
Port_2966489_10 | SOURCEANDSINK | URB.EP 4
Port_2985474_1 | SOURCEANDSINK | URB.EP 4
Port_2966489_13 | SOURCEANDSINK | URB.EP 4
Port_2985490_0 | SOURCEANDSINK | URB.EP 4
OutPort_2966649_1 | SOURCE | URB.EP 4
Port_2966649_10 | SOURCEANDSINK | URB.EP 4
Port_2985490_1 | SOURCEANDSINK | URB.EP 4
Port_2966649_13 | SOURCEANDSINK | URB.EP 4
Port_2985502_0 | SOURCEANDSINK | URB.EP 4
OutPort_2966733_1 | SOURCE | URB.EP 4
Port_2966733_10 | SOURCEANDSINK | URB.EP 4
Port_2985502_1 | SOURCEANDSINK | URB.EP 4
OutPort_2966733_13 | SOURCE | URB.EP 4
OutPort_2966925_5 | SOURCE | URB.EP 4
Port_2966925_10 | SOURCEANDSINK | URB.EP 4
Port_2985438_0 | SOURCEANDSINK | URB.EP 4
Port_2966925_13 | SOURCEANDSINK | URB.EP 4
Port_2985426_1 | SOURCEANDSINK | URB.EP 4
OutPort_2967061_5 | SOURCE | URB.EP 4
Port_2967061_10 | SOURCEANDSINK | URB.EP 4
Port_2985426_0 | SOURCEANDSINK | URB.EP 4
Port_2967061_13 | SOURCEANDSINK | URB.EP 4
Port_2985414_1 | SOURCEANDSINK | URB.EP 4
OutPort_2967252_1 | SOURCE | URB.EP 4
Port_2967252_10 | SOURCEANDSINK | URB.EP 4
Port_2985402_1 | SOURCEANDSINK | URB.EP 4
Port_2967252_13 | SOURCEANDSINK | URB.EP 4
Port_2985414_0 | SOURCEANDSINK | URB.EP 4
OutPort_2967471_1 | SOURCE | URB.EP 4
Port_2967471_10 | SOURCEANDSINK | URB.EP 4
Port_2985378_1 | SOURCEANDSINK | URB.EP 4
Port_2967471_13 | SOURCEANDSINK | URB.EP 4
Port_2985390_0 | SOURCEANDSINK | URB.EP 4
OutPort_2967558_1 | SOURCE | URB.EP 4
Port_2967558_10 | SOURCEANDSINK | URB.EP 4
Port_2985358_1 | SOURCEANDSINK | URB.EP 4
Port_2967558_13 | SOURCEANDSINK | URB.EP 4
Port_2985378_0 | SOURCEANDSINK | URB.EP 4
OutPort_2967675_1 | SOURCE | URB.EP 4
Port_2967675_10 | SOURCEANDSINK | URB.EP 4
Port_2985346_1 | SOURCEANDSINK | URB.EP 4
Port_2967675_13 | SOURCEANDSINK | URB.EP 4
Port_2985358_0 | SOURCEANDSINK | URB.EP 4
OutPort_2967802_1 | SOURCE | URB.EP 4
Port_2967802_10 | SOURCEANDSINK | URB.EP 4
Port_2985334_1 | SOURCEANDSINK | URB.EP 4
Port_2967802_13 | SOURCEANDSINK | URB.EP 4
Port_2985346_0 | SOURCEANDSINK | URB.EP 4
OutPort_2967959_1 | SOURCE | URB.EP 4
Port_2967959_10 | SOURCEANDSINK | URB.EP 4
Port_2985322_1 | SOURCEANDSINK | URB.EP 4
Port_2967959_13 | SOURCEANDSINK | URB.EP 4
Port_2985334_0 | SOURCEANDSINK | URB.EP 4
OutPort_2968102_1 | SOURCE | URB.EP 4
Port_2968102_5 | SOURCEANDSINK | URB.EP 4
Port_2985266_0 | SOURCEANDSINK | URB.EP 4
Port_2968102_10 | SOURCEANDSINK | URB.EP 4
Port_2985246_1 | SOURCEANDSINK | URB.EP 4
Port_2968102_13 | SOURCEANDSINK | URB.EP 4
Port_2985322_0 | SOURCEANDSINK | URB.EP 4
OutPort_2968147_1 | SOURCE | URB.EP 4
Port_2968147_10 | SOURCEANDSINK | URB.EP 4
Port_2985234_1 | SOURCEANDSINK | URB.EP 4
Port_2968147_13 | SOURCEANDSINK | URB.EP 4
Port_2985246_0 | SOURCEANDSINK | URB.EP 4
Port_2968422_1 | SOURCEANDSINK | URB.EP 4
Port_2985222_0 | SOURCEANDSINK | URB.EP 4
Port_2968422_5 | SOURCEANDSINK | URB.EP 4
Port_2985210_1 | SOURCEANDSINK | URB.EP 4
OutPort_2968422_10 | SOURCE | URB.EP 4
OutPort_2968422_13 | SOURCE | URB.EP 4
OutPort_2968438_1 | SOURCE | URB.EP 4
Port_2968438_10 | SOURCEANDSINK | URB.EP 4
Port_2985222_1 | SOURCEANDSINK | URB.EP 4
Port_2968438_13 | SOURCEANDSINK | URB.EP 4
Port_2985234_0 | SOURCEANDSINK | URB.EP 4
OutPort_2968521_1 | SOURCE | URB.EP 5
OutPort_2968521_5 | SOURCE | URB.EP 5
Port_2968521_10 | SOURCEANDSINK | URB.EP 5
Port_2985590_0 | SOURCEANDSINK | URB.EP 5
Port_2968521_13 | SOURCEANDSINK | URB.EP 5
Port_2989973_0 | SOURCEANDSINK | URB.EP 5
OutPort_2968560_1 | SOURCE | URB.EP 4
Port_2968560_10 | SOURCEANDSINK | URB.EP 4
Port_2985198_1 | SOURCEANDSINK | URB.EP 4
Port_2968560_13 | SOURCEANDSINK | URB.EP 4
Port_2985210_0 | SOURCEANDSINK | URB.EP 4
OutPort_2968615_1 | SOURCE | URB.EP 4
Port_2968615_10 | SOURCEANDSINK | URB.EP 4
Port_2985182_1 | SOURCEANDSINK | URB.EP 4
Port_2968615_13 | SOURCEANDSINK | URB.EP 4
Port_2985198_0 | SOURCEANDSINK | URB.EP 4
Port_2968833_1 | SOURCEANDSINK | URB.EP 4
Port_2985182_0 | SOURCEANDSINK | URB.EP 4
Port_2968833_5 | SOURCEANDSINK | URB.EP 4
Port_2985162_1 | SOURCEANDSINK | URB.EP 4
OutPort_2968833_10 | SOURCE | URB.EP 4
OutPort_2969008_1 | SOURCE | URB.EP 4
Port_2969008_10 | SOURCEANDSINK | URB.EP 4
Port_2985150_1 | SOURCEANDSINK | URB.EP 4
Port_2969008_13 | SOURCEANDSINK | URB.EP 4
Port_2985162_0 | SOURCEANDSINK | URB.EP 4
OutPort_2969038_1 | SOURCE | URB.EP 4
Port_2969038_10 | SOURCEANDSINK | URB.EP 4
Port_2985138_1 | SOURCEANDSINK | URB.EP 4
Port_2969038_13 | SOURCEANDSINK | URB.EP 4
Port_2985150_0 | SOURCEANDSINK | URB.EP 4
OutPort_2969051_1 | SOURCE | URB.EP 4
Port_2969051_10 | SOURCEANDSINK | URB.EP 4
Port_2985126_1 | SOURCEANDSINK | URB.EP 4
Port_2969051_13 | SOURCEANDSINK | URB.EP 4
Port_2985138_0 | SOURCEANDSINK | URB.EP 4
OutPort_2969208_1 | SOURCE | URB.EP 4
Port_2969208_10 | SOURCEANDSINK | URB.EP 4
Port_2985114_1 | SOURCEANDSINK | URB.EP 4
Port_2969208_13 | SOURCEANDSINK | URB.EP 4
Port_2985126_0 | SOURCEANDSINK | URB.EP 4
OutPort_2969570_1 | SOURCE | URB.EP 4
Port_2969570_5 | SOURCEANDSINK | URB.EP 4
Port_2989814_0 | SOURCEANDSINK | URB.EP 4
Port_2969570_10 | SOURCEANDSINK | URB.EP 4
Port_2985028_1 | SOURCEANDSINK | URB.EP 4
Port_2969570_13 | SOURCEANDSINK | URB.EP 4
Port_2985044_0 | SOURCEANDSINK | URB.EP 4
OutPort_2969761_1 | SOURCE | URB.EP 3
OutPort_2969761_5 | SOURCE | URB.EP 3
OutPort_2969761_10 | SOURCE | URB.EP 3
Port_2969761_13 | SOURCEANDSINK | URB.EP 3
Port_2984919_1 | SOURCEANDSINK | URB.EP 3
OutPort_2971638_1 | SOURCE | URB.EP 4
OutPort_2971638_10 | SOURCE | URB.EP 4
Port_2971638_13 | SOURCEANDSINK | URB.EP 4
Port_2985266_1 | SOURCEANDSINK | URB.EP 4
OutPort_2972500_1 | SOURCE | URB.EP 7
OutPort_2972500_5 | SOURCE | URB.EP 7
OutPort_2972500_10 | SOURCE | URB.EP 7
Port_2972500_13 | SOURCEANDSINK | URB.EP 7
Port_2989840_0 | SOURCEANDSINK | URB.EP 7
Port_2984811_0 | SOURCEANDSINK | URB.EP 2
Port_2984811_1 | SOURCEANDSINK | URB.EP 2
Port_2984919_0 | SOURCEANDSINK | URB.EP 3
Port_2985016_0 | SOURCEANDSINK | URB.EP 4
Port_2985016_1 | SOURCEANDSINK | URB.EP 4
Port_2985028_0 | SOURCEANDSINK | URB.EP 4
Port_2985044_1 | SOURCEANDSINK | URB.EP 4
Port_2985094_0 | SOURCEANDSINK | URB.EP 4
Port_2985094_1 | SOURCEANDSINK | URB.EP 4
Port_2985114_0 | SOURCEANDSINK | URB.EP 4
Port_2985550_0 | SOURCEANDSINK | URB.EP 4
Port_2985550_1 | SOURCEANDSINK | URB.EP 4
Port_2985590_1 | SOURCEANDSINK | URB.EP 5
Port_2985637_0 | SOURCEANDSINK | URB.EP 6
Port_2985637_1 | SOURCEANDSINK | URB.EP 6
Port_2989801_0 | SOURCEANDSINK | URB.EP 4
Port_2989827_0 | SOURCEANDSINK | URB.EP 3
Port_2991923_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_2991923_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3028241_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3021999_1 | SOURCEANDSINK | IF.FONT.Reg 2
Port_3021999_5 | SOURCEANDSINK | IF.FONT.Reg 2
Port_3021999_10 | SOURCEANDSINK | IF.FONT.Reg 2
Port_3028385_0 | SOURCEANDSINK | IF.FONT.Reg 2
Port_3021999_13 | SOURCEANDSINK | IF.FONT.Reg 2
Port_3022263_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3027499_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3022263_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3026553_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3024659_1 | SOURCEANDSINK | IF.FONT.Reg 5
Port_3024659_5 | SOURCEANDSINK | IF.FONT.Reg 5
Port_3024659_10 | SOURCEANDSINK | IF.FONT.Reg 5
Port_3034528_0 | SOURCEANDSINK | IF.FONT.Reg 5
Port_3024659_13 | SOURCEANDSINK | IF.FONT.Reg 5
Port_3024810_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3034486_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3024810_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3024949_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3024829_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025007_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3024829_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3024949_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3024848_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025007_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3024848_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025272_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025025_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025281_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025025_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025272_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025044_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025281_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025044_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025290_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025063_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025299_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025063_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025290_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025082_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025299_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025082_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025497_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025319_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025497_1 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025319_2 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025506_0 | SOURCEANDSINK | IF.FONT.Reg 1
Port_3025362_1 | SOURCEANDSINK | IF.FONT.Reg 1
