Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcFlowSegment: Pipe Types:AMB.CLA02.DerivacioEmbornalPVC (56)
Name (Pipe Types:AMB.CLA02.DerivacioEmbornalPVC:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 119.AMB.FaseCreacio | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
3353034 | 9.68 | 7.90693 | Fase 1 | 400 mmø | 12.1642 | 0.4 | URB.DRE.Embornal 12
3353391 | 5.08271 | 7.8561 | Fase 1 | 400 mmø | 6.38713 | 0.4 | URB.DRE.Embornal 18
3353409 | 0.915124 | 7.84695 | Fase 1 | 400 mmø | 1.14998 | 0.4 | URB.DRE.Embornal 20
3353431 | 2.87291 | 7.81822 | Fase 1 | 400 mmø | 3.6102 | 0.4 | URB.DRE.Embornal 22
3353448 | 3.24016 | 7.78582 | Fase 1 | 400 mmø | 4.07171 | 0.4 | URB.DRE.Embornal 24
3353671 | 3.84257 | 7.80853 | Fase 1 | 400 mmø | 4.82871 | 0.4 | URB.DRE.Embornal 26
3353691 | 5.05053 | 7.55655 | Fase 1 | 400 mmø | 6.34668 | 0.4 | URB.DRE.Embornal 28
3353996 | 3.96 | 9.60053 | Fase 1 | 400 mmø | 4.97628 | 0.4 | URB.DRE.Embornal 32
3354012 | 3 | 7.39806 | Fase 1 | 400 mmø | 3.76991 | 0.4 | URB.DRE.Embornal 35
3354261 | 3.30049 | 9.3166 | Fase 1 | 400 mmø | 4.14752 | 0.4 | URB.DRE.Embornal 37
3354450 | 3.83573 | 9.11822 | Fase 1 | 400 mmø | 4.82012 | 0.4 | URB.DRE.Embornal 40
3355300 | 3.71527 | 7.70072 | Fase 1 | 400 mmø | 4.66875 | 0.4 | URB.DRE.Embornal 41
3356413 | 6.17261 | 7.36973 | Fase 2 | 400 mmø | 7.75673 | 0.4 | URB.DRE.Embornal 16
3356602 | 2.5 | 6.62343 | Fase 2 | 315 mmø | 2.474 | 0.315 | URB.DRE.Embornal 17
3356836 | 2.3 | 7.01243 | Fase 2 | 315 mmø | 2.27608 | 0.315 | URB.DRE.Embornal 42
3357469 | 8.46042 | 9.13928 | Fase 2 | 400 mmø | 10.6317 | 0.4 | URB.DRE.Embornal 43
3359104 | 3.46017 | 9.23252 | Fase 2 | 400 mmø | 4.34818 | 0.4 | URB.DRE.Embornal 44
3359310 | 10.0715 | 9.10046 | Fase 2 | 400 mmø | 12.6563 | 0.4 | URB.DRE.Embornal 45
3360057 | 10.22 | 8.49901 | Fase 2 | 400 mmø | 12.8428 | 0.4 | URB.DRE.Embornal 46
3360078 | 10.3 | 8.39485 | Fase 2 | 400 mmø | 12.9434 | 0.4 | URB.DRE.Embornal 47
3360097 | 2.20011 | 8.37293 | Fase 2 | 400 mmø | 2.76474 | 0.4 | URB.DRE.Embornal 48
3360573 | 10.76 | 7.99523 | Fase 2 | 400 mmø | 13.5214 | 0.4 | URB.DRE.Embornal 49
3360597 | 1.82 | 7.97424 | Fase 2 | 400 mmø | 2.28708 | 0.4 | URB.DRE.Embornal 50
3361387 | 10.32 | 7.95519 | Fase 2 | 400 mmø | 12.9685 | 0.4 | URB.DRE.Embornal 51
3361408 | 10.24 | 7.8928 | Fase 2 | 400 mmø | 12.868 | 0.4 | URB.DRE.Embornal 52
3361425 | 0.740037 | 7.88533 | Fase 2 | 400 mmø | 0.929958 | 0.4 | URB.DRE.Embornal 53
3361973 | 12.2924 | 7.87227 | Fase 2 | 400 mmø | 15.447 | 0.4 | URB.DRE.Embornal 54
3361990 | 13.0207 | 7.74207 | Fase 2 | 400 mmø | 16.3622 | 0.4 | URB.DRE.Embornal 55
3366993 | 7.34064 | 8.21179 | Fase 1 | 400 mmø | 9.22452 | 0.4 | URB.DRE.Embornal 30

# IfcFlowSegment: Pipe Types:AMB.CLA03.CollectorNoVisitable (11)
In: P0
Type - Material: URB.DRE.General
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLA03; 111.AMB.DescripcioTipus: Col·lector no visitable
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.CLA03.CollectorNoVisitable; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00000254 m
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLA03.CollectorNoVisitable; 112.AMB.Servei: URB.DRE.General; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Preexistència
Name (Pipe Types:AMB.CLA03.CollectorNoVisitable:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
2635523 | 16.343 | 7.91383 | 800 mmø | 41.0744 | 0.8 | URB.DRE.General 3
2637143 | 48.5163 | 7.42363 | 800 mmø | 121.935 | 0.8 | URB.DRE.General 3; URB.DRE.Embornal 41
3051132 | 24.1901 | 7.93629 | 800 mmø | 60.7964 | 0.8 | URB.DRE.General 3
3051316 | 5.6068 | 6.92802 | 800 mmø | 14.0914 | 0.8 | URB.DRE.General 3
3079089 | 47.6264 | 8.10371 | 800 mmø | 119.698 | 0.8 | URB.DRE.General 3
3351684 | 1.04362 | 6.80777 | 800 mmø | 2.6229 | 0.8 | URB.DRE.General 3
3372075 | 1.8108 | 7.10321 | 500 mmø | 2.84439 | 0.5 | URB.DRE.General 3
3372092 | 52.4831 | 7.13852 | 500 mmø | 82.4402 | 0.5 | URB.DRE.General 3
3372116 | 28.2957 | 7.68052 | 500 mmø | 44.4468 | 0.5 | URB.DRE.General 3
3372134 | 12.4406 | 7.98066 | 500 mmø | 19.5416 | 0.5 | URB.DRE.General 3
3372199 | 8.27137 | 6.92862 | 500 mmø | 12.9926 | 0.5 | URB.DRE.General 3

# IfcFlowSegment: Pipe Types:AMB.CLA04.CollectorSemiVisitable (6)
In: P0
Type - Material: URB.DRE.General
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLA04; 111.AMB.DescripcioTipus: Col·lector semivisitable
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat); Group: URB.DRE.General 3
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.CLA04.CollectorSemiVisitable; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00000254 m
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLA04.CollectorSemiVisitable; 112.AMB.Servei: URB.DRE.General; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Preexistència
2 AMB.Caracteristiques - 242.AMB.Mida: 800 mmø
5 AMB.Geometria - 505.AMB.Diametre: 0.8 m
Name (Pipe Types:AMB.CLA04.CollectorSemiVisitable:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 507.AMB.Area (m2)
2671214 | 3.50232 | 6.76708 | 8.8023
3052213 | 12.0322 | 6.62543 | 30.2402
3077166 | 121.025 | 6.67639 | 304.17
3077270 | 18.0047 | 6.44539 | 45.2508
3078955 | 35.0881 | 6.59752 | 88.186
3372403 | 0.970648 | 6.77216 | 2.4395

# IfcFlowSegment: Pipe Types:AMB.CLA05.NouCollector (6)
In: P0
Type - Material: URB.DRE.NouCol·lector
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.30.10: Canalitzacions de drenatge; 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge; 109.AMB.CodiTipus: CLA05; 111.AMB.DescripcioTipus: Nou Col·lector
Classification: 70.40.30.10 Canalitzacions de drenatge (Default Classification); 70.40.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.CLA05.NouCollector; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00000254 m
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.CLA05.NouCollector; 112.AMB.Servei: URB.DRE.NouCol·lector; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador; 119.AMB.FaseCreacio: Fase 1
2 AMB.Caracteristiques - 242.AMB.Mida: 500 mmø
5 AMB.Geometria - 505.AMB.Diametre: 0.5 m
Name (Pipe Types:AMB.CLA05.NouCollector:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 507.AMB.Area (m2) | Group
3371815 | 12.1901 | 8.11335 | 19.1481 | URB.DRE.NouCol·lector 2
3371817 | 14.0187 | 7.98101 | 22.0206 | URB.DRE.NouCol·lector 4
3371819 | 13.2188 | 8.05073 | 20.764 | URB.DRE.NouCol·lector 4
3371823 | 28.7142 | 7.8311 | 45.1041 | URB.DRE.NouCol·lector 3
3371825 | 27.5634 | 7.686 | 43.2965 | URB.DRE.NouCol·lector 5
3371827 | 7.8817 | 7.05042 | 12.3805 | URB.DRE.NouCol·lector 1; URB.DRE.General 3

# IfcFlowTerminal: AMB.Columna.Disseny.Multi:AMB.EPE02.ColumnaLluminariaGYTECH.4,50m (27)
In: P0
Type - Classification: 70.40.10.10 Lluminàries i bàculs (Default Classification); Material: AMB.Metall.Acer.Lacat.Negre, AMB.Llum.Blanc
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.10.10: Lluminàries i bàculs; 104.AMB.ClassificacioCodi: 70.40.10.10; 105.AMB.ClassificacioDescripcio: Lluminàries i bàculs; 109.AMB.CodiTipus: EPE02; 111.AMB.DescripcioTipus: Columna luminaria GYTECH
Classification: 70.40.10.10 Lluminàries i bàculs (Default Classification); 70.40.10.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.Columna.Disseny.Multi:AMB.EPE02.ColumnaLluminariaGYTECH.4,50m; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.EPE02.ColumnaLluminariaGYTECH.4,50m; 112.AMB.Servei: URB.EP; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 3.56608 m2; 509.AMB.Volum: 0.095357 m3
Name (AMB.Columna.Disseny.Multi:AMB.EPE02.ColumnaLluminariaGYTECH.4,50m:...) | 119.AMB.FaseCreacio
2758872 | Fase 1
2926600 | Fase 1
2926813 | Fase 1
2927053 | Fase 1
2927221 | Fase 1
2927486 | Fase 1
2927656 | Fase 1
2927878 | Fase 1
2928133 | Fase 1
2928301 | Fase 1
2928451 | Fase 1
2928670 | Fase 1
2928895 | Fase 1
2929010 | Fase 2
2929311 | Fase 2
2929401 | Fase 2
2929445 | Fase 2
2929670 | Fase 2
2929967 | Fase 2
2930043 | Fase 2
2930095 | Fase 2
2930268 | Fase 2
2930455 | Fase 2
2930720 | Fase 2
2931044 | Fase 2
2931246 | Fase 2
2931438 | Fase 2

# IfcFlowTerminal: AMB.PuntLlum.Fonamentacio:AMB.EPL01.NovaLluminariaLEDMizarRJ.4,50m (21)
In: P0
Type - Classification: 70.40.10.10 Lluminàries i bàculs (Default Classification); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.10.10: Lluminàries i bàculs; 104.AMB.ClassificacioCodi: 70.40.10.10; 105.AMB.ClassificacioDescripcio: Lluminàries i bàculs; 109.AMB.CodiTipus: EPL01; 111.AMB.DescripcioTipus: Luminaria orientable Led Mizar RJ
Classification: 70.40.10.10 Lluminàries i bàculs (Default Classification); 70.40.10.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.PuntLlum.Fonamentacio:AMB.EPL01.NovaLluminariaLEDMizarRJ.4,50m; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.EPL01.NovaLluminariaLEDMizarRJ.4,50m; 112.AMB.Servei: URB.EP; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 1.76928 m2; 509.AMB.Volum: 0.216359 m3
Name (AMB.PuntLlum.Fonamentacio:AMB.EPL01.NovaLluminariaLEDMizarRJ.4,50m:...) | 119.AMB.FaseCreacio | Group
2757909 | Fase 1 | URB.EP 4
2926599 | Fase 1 | URB.EP 4
2926812 | Fase 1 | URB.EP 4
2927877 | Fase 1 | URB.EP 4
2928132 | Fase 1 | URB.EP 4
2928300 | Fase 1 | URB.EP 4
2928450 | Fase 1 | URB.EP 4
2928669 | Fase 1 | URB.EP 4
2928894 | Fase 1 | URB.EP 4
2929009 | Fase 2 | URB.EP 4
2929310 | Fase 2 | URB.EP 5
2929400 | Fase 2 | URB.EP 4
2929444 | Fase 2 | URB.EP 4
2929669 | Fase 2 | URB.EP 4
2929966 | Fase 2 | URB.EP 4
2930042 | Fase 2 | URB.EP 4
2930094 | Fase 2 | URB.EP 4
2930267 | Fase 2 | URB.EP 4
2930454 | Fase 2 | URB.EP 4
2930719 | Fase 2 | URB.EP 4
2931043 | Fase 2 | URB.EP 4

# IfcFlowTerminal: AMB.PuntLlum.Fonamentacio:AMB.EPL02.NovaLluminariaLEDMizarRE.4,50m (6)
In: P0
Type - Classification: 70.40.10.10 Lluminàries i bàculs (Default Classification); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 103.AMB.Classificacio: 70.40.10.10: Lluminàries i bàculs; 104.AMB.ClassificacioCodi: 70.40.10.10; 105.AMB.ClassificacioDescripcio: Lluminàries i bàculs; 109.AMB.CodiTipus: EPL02; 111.AMB.DescripcioTipus: Luminaria orientable Led Mizar RE
Classification: 70.40.10.10 Lluminàries i bàculs (Default Classification); 70.40.10.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.PuntLlum.Fonamentacio:AMB.EPL02.NovaLluminariaLEDMizarRE.4,50m; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.EPL02.NovaLluminariaLEDMizarRE.4,50m; 112.AMB.Servei: URB.EP; 115.AMB.Nivell: P0; 117.AMB.Localitzacio: A.SantSalvador
5 AMB.Geometria - 507.AMB.Area: 1.76928 m2; 509.AMB.Volum: 0.216384 m3
Name (AMB.PuntLlum.Fonamentacio:AMB.EPL02.NovaLluminariaLEDMizarRE.4,50m:...) | 119.AMB.FaseCreacio | Group
2927052 | Fase 1 | URB.EP 4
2927220 | Fase 1 | URB.EP 4
2927485 | Fase 1 | URB.EP 4
2927655 | Fase 1 | URB.EP 4
2931245 | Fase 2 | URB.EP 3
2931437 | Fase 2 | URB.EP 7

# IfcSystem: IF.FONT.RegPrimari, IF.FONT.RegPrimari 1
1 AMB.Identificacio - 107.AMB.NomTipus: IF.FONT.RegPrimari
5 AMB.Geometria - 509.AMB.Volum: 0.0562805 m3

# IfcSystem: IF.FONT.RegPrimariBoquesReg (2)
1 AMB.Identificacio - 107.AMB.NomTipus: IF.FONT.RegPrimariBoquesReg
Name | 509.AMB.Volum (m3)
IF.FONT.RegPrimariBoquesReg 2 | 0.693308
IF.FONT.RegPrimariBoquesReg 1 | 0.00440005

# IfcSystem: IF.FONT.RegSecundari (9)
1 AMB.Identificacio - 107.AMB.NomTipus: IF.FONT.RegSecundari
Name | 509.AMB.Volum (m3)
IF.FONT.Reg 1 | 0.248727
IF.FONT.Reg 2 | 0.00959898
IF.FONT.Reg 5 | 0.00722124
IF.FONT.Reg 3
IF.FONT.Reg 4 | 0.202974
IF.FONT.Reg 7 | 0.00879906
IF.FONT.RegSecundari 1 | 0.00377462
IF.FONT.Reg 8 | 0.0235984
IF.FONT.RegSecundari 2 | 0.0139263

# IfcSystem: URB.DRE.Embornal (55)
1 AMB.Identificacio - 107.AMB.NomTipus: URB.DRE.Embornal
Name
URB.DRE.Embornal 30
URB.DRE.Embornal 55
URB.DRE.Embornal 54
URB.DRE.Embornal 1
URB.DRE.Embornal 7
URB.DRE.Embornal 9
URB.DRE.Embornal 11
URB.DRE.Embornal 13
URB.DRE.Embornal 15
URB.DRE.Embornal 19
URB.DRE.Embornal 21
URB.DRE.Embornal 23
URB.DRE.Embornal 25
URB.DRE.Embornal 27
URB.DRE.Embornal 29
URB.DRE.Embornal 31
URB.DRE.Embornal 36
URB.DRE.Embornal 64
URB.DRE.Embornal 61
URB.DRE.Embornal 58
URB.DRE.Embornal 34
URB.DRE.Embornal 33
URB.DRE.Embornal 2
URB.DRE.Embornal 3
URB.DRE.Embornal 4
URB.DRE.Embornal 5
URB.DRE.Embornal 6
URB.DRE.Embornal 10
URB.DRE.Embornal 8
URB.DRE.Embornal 12
URB.DRE.Embornal 18
URB.DRE.Embornal 20
URB.DRE.Embornal 22
URB.DRE.Embornal 24
URB.DRE.Embornal 26
URB.DRE.Embornal 28
URB.DRE.Embornal 32
URB.DRE.Embornal 35
URB.DRE.Embornal 37
URB.DRE.Embornal 40
URB.DRE.Embornal 41
URB.DRE.Embornal 16
URB.DRE.Embornal 17
URB.DRE.Embornal 42
URB.DRE.Embornal 43
URB.DRE.Embornal 44
URB.DRE.Embornal 45
URB.DRE.Embornal 46
URB.DRE.Embornal 47
URB.DRE.Embornal 48
URB.DRE.Embornal 49
URB.DRE.Embornal 50
URB.DRE.Embornal 51
URB.DRE.Embornal 52
URB.DRE.Embornal 53

# IfcSystem: URB.DRE.General, URB.DRE.General 3
1 AMB.Identificacio - 107.AMB.NomTipus: URB.DRE.General

# IfcSystem: URB.DRE.NouCol·lector (5)
1 AMB.Identificacio - 107.AMB.NomTipus: URB.DRE.NouCol·lector
Name
URB.DRE.NouCol·lector 1
URB.DRE.NouCol·lector 5
URB.DRE.NouCol·lector 3
URB.DRE.NouCol·lector 4
URB.DRE.NouCol·lector 2

# IfcSystem: URB.EP (6)
1 AMB.Identificacio - 107.AMB.NomTipus: URB.EP
Name | 509.AMB.Volum (m3)
URB.EP 4 | 10.6315
URB.EP 5 | 0.158499
URB.EP 3 | 0.248026
URB.EP 7 | 0.118785
URB.EP 2 | 0.290777
URB.EP 6 | 0.657356
